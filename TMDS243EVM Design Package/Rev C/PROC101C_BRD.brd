# Allegro board PROC101C_BRD.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VDDA_1V8 on L06_PWR2: 89.46,54.75 75.06,69.15 75.06,78.5 71.02,82.54 71.02,84.9 71.4,85.28 76.4,85.28 79.91,81.78 79.91,75.88 81.02,74.77 81.02,70.98 89.61,62.39 92.53,62.39 96.17,66.03 104.37,66.03 109.73,71.39 133.86,71.39 133.86,67.58 131.95,65.67 112.43,65.67 101.51,54.75 ; 3 cut-outs
VDDA_1V8 on L08_SIG2: 89.42,74.09 89.42,77.53 90.18,78.29 94.75,78.29 95.28,77.77 95.28,74.74 94.19,73.65 89.86,73.65
VDDA_1V8_MCU on TOP: 106.43,72.53 110.45,72.53 110.45,69.86 107.44,69.86 107.19,69.61 106.43,69.61
VDDA_1V8_MCU on BOTTOM: 108.66,72.66 110.24,72.66 110.24,70.66 108.66,70.66
VDDA_1V8_MCU on L05_PWR1: 92.03,76.09 92.03,75.73 91.59,75.3 91.59,74.36 91.86,74.09 92.04,74.09 93.91,72.22 98.84,72.22 100.31,70.75 110.11,70.75 110.24,70.88 110.24,75.66 93.85,75.66 93.52,75.33 92.91,75.33 92.5,75.74 92.5,76.09 92.44,76.15 92.08,76.15 ; 1 cut-out
VDDA_1V8_SERDES on TOP: 88.27,58.94 88.27,65.42 92.33,65.42 92.33,58.94
VDDA_1V8_SERDES on L05_PWR1: 86.04,66.85 86.04,64.55 86.4,64.19 90.82,64.19 91.12,64.49 91.12,65.86 87.76,69.23 87.76,74.43 87.14,75.05 80.57,75.05 80.57,67.77 80.58,67.77 85.12,67.77
VDDA_1V8_USB0 on BOTTOM: 88.2,62.35 88.2,65.63 92.36,65.63 92.36,62.75 91.06,62.75 91.06,59.04 89.43,59.04 89.43,62.35
VDDA_1V8_USB0 on L06_PWR2: 85.89,73.93 87.63,73.93 87.88,73.67 87.88,69.23 90.68,66.44 92.58,66.44 92.96,66.05 92.96,63.64 92.33,63.01 89.71,63.01 85.27,67.44 85.27,73.32
VDDA_ADC on BOTTOM: 109.35,74.96 109.35,72.93 110.62,72.93 110.62,71.64 112.24,71.64 112.4,71.81 112.4,74.96
VDDA_CORE on TOP: 113.16,100.68 118.56,100.68 118.56,94.4 116.59,94.4 116.59,96.56 116.12,97.03 113.16,97.03
VDDA_CORE on BOTTOM: 69.77,77.99 69.77,81.76 72.26,81.76 72.26,77.99
VDDA_CORE on BOTTOM: 116.2,72.03 116.2,70.1 118.69,70.1 118.69,71.58 118.06,71.58 117.6,72.03
VDDA_CORE on L03_SIG1: 117.22,70.88 117.22,69.74 118.87,69.74 118.87,70.88
VDDA_CORE on L03_SIG1: 113.28,100.98 113.28,99.84 115.57,99.84 115.57,100.98
VDDA_CORE on L05_PWR1: 70.41,79.34 70.41,80.23 72.19,80.23 72.19,79.34
VDDA_CORE on L05_PWR1: 113.28,100.85 113.28,99.84 115.44,99.84 115.44,100.85
VDDA_PLL0 on BOTTOM: 72.62,82.29 75.39,82.29 76.31,81.36 77.45,81.36 77.55,81.46 79.27,81.46 79.35,81.38 79.35,82.69 78.36,83.68 72.62,83.68
VDDA_PLL1 on BOTTOM: 103.31,78.63 109.5,78.63 109.5,80.23 103.31,80.23
VDDA_PLL2 on TOP: 105.03,87.52 105.03,85.36 106.03,85.36 106.29,85.61 111.38,85.61 111.38,87.52
VDDAR_0P85_SERDES0 on TOP: 72.9,77.48 75.69,77.48 75.69,75.71 72.9,75.71
VDDAR_0P85_SERDES0 on BOTTOM: 71.5,74.69 71.5,77.36 72.75,77.36 72.75,79.19 74.14,79.19 74.14,74.69
VDDAR_0P85_SERDES0 on L05_PWR1: 73.37,78.85 87.54,78.85 88.59,77.8 88.59,74.93 88.03,74.93 87.17,75.78 86.74,75.78 86.64,75.68 86.54,75.68 85.85,76.37 82.07,76.37 81.49,75.79 75.58,75.79 74.6,74.82 72.77,74.82 72.39,75.2 72.39,77.87
VDDAR_0P85_USB0 on BOTTOM: 72.75,81.96 72.75,80.02 74.52,80.02 74.52,74.78 76.54,74.78 76.71,74.94 76.71,75.88 76.12,76.47 76.12,80.67 74.84,81.96
VDDAR_CORE on TOP: 113.28,96.22 113.28,90.87 119.76,90.87 119.94,91.05 119.94,93.69 119.89,93.74 116.33,93.74 116.08,93.99 116.08,95.77 115.64,96.22
VDDAR_CORE on TOP: 150.15,115.2 150.15,111.75 145.14,111.75 145.14,116.47 148.88,116.47
VDDAR_CORE on BOTTOM: 150.15,116.47 150.15,111.75 150.11,111.75 150.5,111.37 150.5,105.55 149.86,104.92 148.59,104.92 147.57,105.93 147.57,109.32 145.14,111.75 145.14,116.47
VDDAR_CORE on L03_SIG1: 123.83,116.47 150.75,116.47 150.75,112.54 147.7,109.49 142.77,109.49 130.84,97.55 120.9,97.55 116.97,93.61 116.97,91.12 112.65,91.12 112.65,96.6 123.83,107.77
VDDC_1V2 on TOP: 163.32,21.86 163.32,23.18 168.04,23.18 168.04,21.86
VDDR_CORE on TOP: 107.19,80.34 107.19,78.63 111.72,78.63 111.72,80.34
VDDR_CORE on TOP: 116.68,80.48 116.68,80.02 118.92,80.02 118.97,80.08 118.97,81.85 118.85,81.98 118.85,83.68 119.3,84.14 120.65,84.14 120.65,89.53 120.65,89.96 115.42,89.96 115.42,81.75
VDDR_CORE on L05_PWR1: 88.88,75.77 90.45,77.34 90.45,78.65 90.57,78.77 91.57,78.77 91.7,78.64 91.7,77.4 90.73,76.44 90.73,74.89 93.9,71.72 98.04,71.72 100.15,69.61 110.36,69.61 111,70.25 111,76.21 109.47,77.74 109.47,80.79 109.6,80.91 113.46,80.91 116.36,83.81 118.49,83.81 118.49,82.31 119,81.8 119,80.15 118.52,79.67 118.52,76.1 118.49,76.08 118.49,74.24 112.09,67.83 111.49,67.83 109.29,65.64 97.57,65.64 95.38,67.83 90.81,67.83 88.88,69.76
VDDR_VTT on TOP: 84.33,95.39 96.77,95.39 96.77,97.92 98.68,97.92 98.68,93.61 82.65,93.61 81.15,95.12 81.15,97.93 83.06,97.93 84.07,96.92 84.07,95.65
VDDR_VTT on BOTTOM: 77.22,118.63 77.22,117.11 77.72,117.11 77.72,117.74 78.61,118.63 78.61,120.65 80.21,122.25 80.21,123.89 77.34,123.89 77.34,118.76
VDDR_VTT on BOTTOM: 81.41,95.51 81.41,106.87 83.95,106.87 83.95,95.9 84.96,94.88 94.17,94.88 94.17,91.9 92.81,91.9 92.81,92.53 92.26,93.08 83.84,93.08
VDDR_VTT on L05_PWR1: 76.96,124.09 76.96,121.55 78.23,120.28 78.23,117.11 81.92,113.43 81.92,95.26 96.79,95.26 101.73,100.2 101.73,106.19 86.23,106.19 86.23,117.74 78.99,124.98 77.85,124.98
VDDSHV_SD_IO on BOTTOM: 90.93,74.55 91.95,74.55 91.95,73.91 92.58,73.91 92.58,73.15 91.06,73.15 91.06,69.47 91.82,68.71 91.82,67.69 93.09,67.69 93.22,67.56 93.22,66.17 90.17,66.17 90.17,73.41 90.93,74.17
VDDSHV_SD_IO on L05_PWR1: 36.64,28.21 43.69,28.21 47.75,32.27 47.75,56.15 58.43,66.83 94.73,66.83 95.63,65.93 95.63,62.24 92.49,59.09 58.77,59.09 54.1,54.43 54.1,31.26 47.5,24.65 36.84,24.65 36.4,25.09 36.4,27.97
(no net) on TOP: outline of 123 points within 1.02,8.02 176.78,132.98 ; 57 cut-outs
(no net) on BOTTOM: 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,69.42 1.65,69.42 4.47,72.24 6.78,72.24 8.46,70.56 9.19,70.56 9.7,71.07 12.78,71.07 12.78,69.14 16.43,65.48 18.24,65.48 19.38,66.62 19.38,68.66 18.29,69.75 16.66,69.75 13.79,72.62 4.7,72.62 3.25,71.17 1.02,71.17 1.02,83.31 2.24,84.53 2.24,86.46 1.02,87.68 1.02,130.07 3.93,132.98 170.69,132.98 176.78,126.89 176.78,44.62 176.2,44.62 174.73,43.16 176.2,41.69 176.78,41.69 176.78,39.87 176.2,39.87 174.73,38.41 176.2,36.94 176.78,36.94 176.78,27.48 176.2,27.48 174.73,26.01 176.2,24.55 176.78,24.55 176.78,22.73 176.2,22.73 174.73,21.26 176.2,19.8 176.78,19.8 176.78,11.98 172.82,8.02 5.47,8.02 1.02,12.47 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 ; 65 cut-outs
(no net) on L03_SIG1: outline of 138 points within 1.02,8.02 176.78,132.98 ; 138 cut-outs
(no net) on L08_SIG2: 1.02,8.03 1.02,47.69 1.02,47.69 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,60.87 1.02,60.87 1.02,61.94 1.02,61.94 1.02,66.84 1.02,66.84 1.02,132.98 176.78,132.98 176.78,111.39 176.78,111.39 176.78,106.82 176.78,106.82 176.78,8.02 50.31,8.02 50.31,8.03 ; 148 cut-outs
CPSW_EARTH on TOP: 2.79,90.69 1.02,92.47 1.02,110.5 1.04,110.5 1.04,111.2 10.97,111.2 11.96,110.21 11.96,104.69 10.74,103.47 10.74,95.69 12.67,93.77 15.49,93.77 15.49,91.2 14.99,90.69
CPSW_EARTH on BOTTOM: 1.76,91.73 1.02,92.47 1.02,110.59 1.4,110.97 10.95,110.97 11.94,109.98 11.94,104.67 10.74,103.48 10.74,95.58 12.57,93.75 15.09,93.75 15.09,91.03 4.45,91.03 3.75,91.73
DDR_VPP on BOTTOM: 87.38,109.49 87.38,109.97 86.33,111.02 83.39,111.02 83.39,109.35 86.6,109.35 86.74,109.49
DDR_VREFCA on BOTTOM: 78.03,115.58 78.03,112.59 79.37,112.59 79.37,115.58
FT4232_USB_VBUS on TOP: 170.88,41.92 170.88,46.24 172.28,46.24 172.28,41.92
FT4232_USB_VBUS on BOTTOM: 164.59,39.13 164.59,45.61 165.74,46.75 171.83,46.75 172.34,46.24 172.34,42.46 168.63,38.75 164.97,38.75
MAIN on TOP: 167.26,119.76 167.26,111.15 166.78,110.67 166.78,106.93 160.42,106.93 160.42,119.76
PRG_EARTH on L02_GND1, L04_GND2, L07_GND3, L09_GND4: 2.66,64.03 1.02,65.67 1.02,87.26 24.38,87.26 27.3,84.34 27.3,81.68 26.42,80.79 9.4,80.79 8.13,79.52 8.13,71.26 10.03,69.36 21.98,69.36 23.39,67.94 23.39,65.38 22.05,64.03
PRG_EARTH on L03_SIG1: 2.66,64.03 1.02,65.67 1.02,88.24 23.41,88.24 27.3,84.34 27.3,81.68 26.42,80.79 9.4,80.79 8.13,79.52 8.13,71.26 10.03,69.36 21.98,69.36 23.39,67.94 23.39,65.38 22.05,64.03
SHIELD on TOP, L02_GND1, L03_SIG1, L04_GND2, L07_GND3, L08_SIG2, L09_GND4: 168.73,110.49 168.73,114.25 173,114.25 173,121.31 172.57,121.74 168.73,121.74 168.73,124.56 176.59,124.56 176.59,110.49
SHIELD on BOTTOM: 168.73,109.34 168.73,114.25 173,114.25 173,121.31 172.57,121.74 168.73,121.74 168.73,124.56 176.59,124.56 176.59,109.34
SOC_DVDD1V8 on TOP: 106.23,74.82 109.44,74.82 109.44,73.04 106.23,73.04
SOC_DVDD1V8 on TOP, BOTTOM: 131.1,112.03 131.1,107.31 126.09,107.31 126.09,112.03
SOC_DVDD1V8 on L03_SIG1: 89.53,73.29 89.53,76.09 89.66,76.21 96.52,76.21 96.65,76.09 96.65,73.55 95.5,72.4 90.42,72.4
SOC_DVDD1V8 on L06_PWR2: 125.98,111.35 125.98,105.24 138.81,92.42 138.81,82.75 132.92,76.86 109.3,76.86 104.31,71.87 94.23,71.87 93.31,72.79 93.31,73.95 92.44,74.83 89.72,74.83 89.51,74.62 89.51,70.76 92.39,67.88 105.45,67.88 109,71.42 134.21,71.42 146.25,83.46 146.25,90.82 131.25,105.82 131.25,110.02 129.92,111.35
SOC_DVDD3V3 on TOP: 137.82,92.98 137.82,88.89 132.88,88.89 132.88,92.98
SOC_DVDD3V3 on BOTTOM: 137.82,92.98 137.82,88.89 132.88,88.89 132.88,92.98
SOC_DVDD3V3 on BOTTOM: 102.83,73.27 105.53,73.27 105.53,74.86 102.83,74.86
SOC_DVDD3V3 on L06_PWR2: 86.61,81.8 90.81,81.8 90.81,79.64 91.19,79.26 93.6,79.26 94.49,80.15 95.12,80.15 96.02,79.26 96.02,77.72 96.87,76.87 99.43,76.87 103.78,81.21 124.55,81.21 132.5,89.16 132.5,92.89 136.86,92.89 137.92,91.84 137.92,87.01 128.63,77.72 108.95,77.72 105.77,74.55 105.77,74.5 104.38,73.11 99.22,73.11 98.45,73.88 93.98,73.88 92.53,75.33 89.54,75.33 88.9,74.68 88.9,72.79 88.14,72.79 88.02,72.9 88.02,73.83 87.69,74.16 86.76,74.16 86.11,74.82 86.11,81.29
USB0_VBUS on TOP: 24.63,51.45 14.73,51.45 9.47,46.19 6.07,46.19 5.16,47.11 5.16,53.3 9.52,53.3 10.97,54.75 24.63,54.75
USB1_SHIELD on TOP: 1.02,49.04 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.85,57.18 2.7,57.5 1.02,57.5 1.02,61.53 5.11,61.53 5.61,61.03 5.61,56.58 5.38,56.35 5.38,49.04
USB1_SHIELD on L03_SIG1: 1.02,49.37 1.02,50.41 1.68,50.41 2.54,50.77 2.9,51.63 2.9,52.08 2.54,52.94 1.68,53.29 1.02,53.29 1.02,55.16 1.68,55.16 2.54,55.52 2.9,56.38 2.9,56.83 2.54,57.69 1.68,58.04 1.02,58.04 1.02,59.15 5.51,59.15 5.51,49.37
VDDS_MMC0/ADC0_VREFP on L08_SIG2: 92.76,73.74 92.76,73.18 92.43,72.85 92.43,69.62 93.55,68.5 95.81,68.5 98.68,65.63 100.69,65.63 100.69,66.95 100.28,67.36 99.26,67.36 97.28,69.34 94.44,69.34 93.88,69.9 93.88,73.13 93.62,73.38 93.62,73.74
VMAIN on TOP: 163.85,76.1 166.11,76.1 166.11,71.95 155.66,71.95 155.66,76.42 158.55,76.42 158.55,83.78 163.85,83.78
VMAIN on TOP: 155.4,61.98 155.4,63 155.27,63.12 153.85,63.12 153.85,62.53 153.82,62.53 152.17,60.88 152.17,58.27 152.27,58.17 153.95,58.17 154.36,58.57 154.36,59.74 154.76,60.15 154.76,61.34
VMAIN on TOP: 148.72,88.41 148.72,93.34 149.63,93.34 151.78,91.19 164.69,91.19 164.69,93.07 165.13,93.5 167.54,93.5 167.54,96.47 173.39,96.47 173.39,88.49 173.31,88.41
VMAIN on BOTTOM: 57.91,22.37 57.91,23.64 57.44,24.11 57.18,24.11 56.77,24.53 56.77,27.59 58.29,27.59 58.29,22.49 58.17,22.37
VMAIN on BOTTOM: 6.99,38.88 11.43,38.88 11.68,38.62 11.68,26.94 11.43,26.68 6.35,26.68 6.35,38.24
VMAIN on L03_SIG1: 151.64,51.96 151.64,80.34 163.19,91.9 172.21,91.9 172.21,81.04 173.35,79.9 173.35,49.8 171.83,48.27 155.32,48.27
VMAIN on L06_PWR2: 164.85,97.41 176.78,97.41 176.78,9.16 9.02,9.16 1.52,16.66 1.52,39.11 14.37,39.11 14.37,26.72 22.34,26.72 30.38,18.68 49.15,18.68 51.82,21.35 51.82,26.58 53.7,28.46 63.37,28.46 63.37,21.39 66.71,18.05 147.07,18.05 164.85,35.83
VPP_1V8 on BOTTOM: 138.81,106.19 138.81,102.38 141.35,102.38 142.37,103.39 142.37,106.19
VPP_DDR_2V5 on BOTTOM: 90.42,128.09 91.82,128.09 91.82,125.36 92.53,124.66 92.53,123.01 90.42,123.01
VPP_DDR_2V5 on BOTTOM: 82.85,108.47 82.85,111.15 80.69,111.15 80.69,108.47
XDS_SHIELD on TOP: 172.85,18.68 172.85,21.99 174.75,21.99 174.75,25.29 174.62,25.41 171.04,25.41 171.04,29.22 177.46,29.22 177.46,18.68
XDS_USB_VBUS on TOP: 167.26,11.78 167.26,13.81 164.2,13.81 164.2,12.86 165.28,11.78
XDS_USB_VBUS on L03_SIG1: 142.62,33.42 142.62,30.24 144.02,28.84 161.42,28.84 164.19,26.07 164.19,12.48 166.12,10.56 171.96,10.56 173.1,11.7 173.1,27.57 166.37,34.3 143.51,34.3
N17786037 on TOP: 32.69,115.33 32.69,121.27 39.75,121.27 39.75,118.51 33.53,118.51 33.02,118 33.02,115.33 33.02,115.33
N17839730 on TOP: 5.89,45.81 5.89,41.32 14.33,41.32 14.33,45.81
N18546005 on TOP: 166.75,105.18 171.08,105.18 172.31,103.94 172.31,96.82 167.34,96.82 167.13,96.62 167.13,94.13 166.98,93.98 164.82,93.98 164.44,94.36 164.44,96.29 164.08,96.65 162.05,96.65 162.05,100.48
N18546005 on L08_SIG2: 166.75,105.18 171.08,105.18 172.31,103.94 172.31,96.82 167.34,96.82 167.13,96.62 167.13,94.13 166.98,93.98 164.82,93.98 164.74,94.06 164.74,95.99 163.86,96.88 162.05,96.88 162.05,100.48
N18968753 on TOP: 33.96,52.59 28.27,52.59 28.02,52.85 28.02,54.88 28.14,55.01 33.96,55.01
N19753729 on TOP: 167.58,80.5 171.13,80.5 171.13,64.78 167.77,64.78 167.77,68.14 166.33,69.57 166.33,74.52 167.58,74.52
N19753760 on TOP: 176.76,78.55 176.76,69.64 173.64,69.64 173.3,69.98 173.3,76.85 173.56,77.11 173.56,78.55
N19754201 on TOP: 151.81,64.15 150.37,65.59 150.37,71.37 151.19,72.2 151.19,76.76 151.63,77.2 151.63,80.56 154.23,80.56 154.23,77.54 154.95,76.81 154.95,71.26 156.03,70.18 156.03,64.15
N19754522 on TOP: 140.13,76.02 146.11,76.02 147.74,74.4 147.74,64.73 140.13,64.73
N26004036 on TOP: 149.95,93.53 151.71,91.76 157.46,91.76 157.46,94.49 149.9,94.49 149.9,93.53
N26016842 on BOTTOM: 57.77,21.1 58.29,21.1 58.29,13.73 56.36,13.73 56.36,18.25 57.77,19.66
N26733205 on TOP: 19.38,61.23 19.38,55.29 12.32,55.29 12.32,59.28 12.34,59.3 16.76,59.3 17.77,58.3 18.78,58.3 19.05,58.56 19.05,61.23 19.05,61.23
N26735457 on TOP: 98.81,119.29 92.96,119.29 92.96,126.35 95.89,126.35 95.89,119.87 96.14,119.62 98.8,119.62 98.81,119.62
N26735496 on BOTTOM: 134.22,122.17 134.22,118.76 140.76,118.76 140.76,122.17
N26736579 on TOP: 124.36,73.08 124.36,76.74 130.71,76.74 130.71,73.08

Small or netless copper shapes (teardrops, artwork): 1371 on TOP, 1130 on BOTTOM, 383 on L03_SIG1, 11 on L05_PWR1, 7 on L06_PWR2, 329 on L08_SIG2

## Text on the board
Ref Des/Assembly Bottom: A | PROC101 ASSEMBLY BOTTOM REV C
Ref Des/Silkscreen Bottom: PCIE RST SEL | A | PCIE PRSNT SEL | FOR EVALUATION ONLY; | NOT FCC APPROVED FOR RESALE
User.Comments: BOARD NAME: | AM64x EVM  BOARD | REV: C | DATE: 12/04/22 | DESCRIPTION: | SHEET | OF | 17 | PROC101C | SCALE: 1 | TEXAS INSTRUMENTS
Ref Des/Assembly Top: PROC101 ASSEMBLY TOP REV C
Ref Des/Silkscreen Top: FSI | MCAN1 | CPSW PHY | HSE | BOOTMODE 0-7 | GND | JTAG MUX SEL | VDD CORE | BOOTMODE 8-15 | I2C0 | VDDR CORE | ADC | MCU RST | SOC WARM RST | I2C1 | MCU RSTSTATz | UART | JTAG | OFF | ON | A | MCAN0 | ICSSG PHY | LATCH IN1 | SYNC OUT2 | LATCH IN0 | SYNC OUT0 | SOC/MCU GPIO | MCU WARM RST | SOC POR RST | RSTSTATz | PORz OUT | SYNC1 OUT | MCU PORz | SAFETY | 12V IN | OFF/ON SWITCH | DISPLAY | PCIE | ASSY# | SL# | AM64x/AM243x EVM | PROC101C | OPN# | USB2.0
PAGE_OUTLINE: LAYOUT BY | REVIEWED BY | APPROVED BY | SIGNATURES | AMB | UD | ZA | DATE | 120422 | SCALE: | SIZE | D | NONE | TEXAS INSTRUMENTS | AM64x  EVM  BOARD | SHEET 1 OF 17 | PROC101C | Rev | C
DISPLAY_TOP: 18. | 16. | 17. | FOR STACKUP DETAIL PROC101_STACKUP.PDF SHALL BE REFERRED. | ENSURE UL REGISTERED E-FILE NUMBER SHALL BE PRINTED ON THE PCB SILKSCREEN. | VIA ON PAD SHALL BE RESIN FILLED AND CAP-PLATED. | DETAIL-A
DIMENSION: 32.725 | BACKING PLATE OUTLINE | NON-PLATED MOUNTING HOLE | 30.225 | SOCKET OUTLINE | 4X | dia | 1.70 | 13.8625 | 8.7825 | 8.0000 | 0 | 0.80 | TYP | 441X | 0.42 | MIN  PADS | 11.3225 | NON-PLATED ALIGNMENT HOLE | 2X | 0.850
User.42: 03 | 04 | 01 | 02 | STRIPLINE | MICROSTRIP | EDGE COUPLED STRIPLINE | EDGE COUPLED MICROSTRIP | L3,L8 | L1,L10 | 3.7 | 4.2 | 5.8 | 9.05 | 3.6 | 6 | 4.4 | NA | 90 | 40 | 50 | L2/L4,L7/L9 | L2,L9
User.45: FIGURE | SIZE | 8.0 | 28.0 | 36.0 | 40.0 | 44.0 | 66.0 | 78.0 | 34.0 | 50.0 | 64.0 | 92.0 | 108.0 | 126.0 | 52.0x24.0 | 52.0x26.0 | 64.0x32.0 | 80.0x40.0 | 82.0x34.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | +1.0/-1.0 | PLATED | NON-PLATED | QTY | 3162 | 64 | 38 | 33 | 101 | 18 | 6 | 1 | 2 | 4 | 13 | 6 - Provide serial numbers to the assembled boards for identification. | 7 - The assembled board are wrapped in ESD Covers(individual) and packed securely before shipment. | ASSEMBLY NOTES:- | 1 - All MSL components should be baked as per JEDEC standard. | 2 - PCB should be baked at 120 degree for 8 hours. | 3 - Board assembly must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified. | 4 - These assemblies are ESD sensitive, ESD precautions shall be observed. | 5 - These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable. | PROC101 E2 ASSEMBLY TOP | PROC101 E2 ASSEMBLY BOTTOM
