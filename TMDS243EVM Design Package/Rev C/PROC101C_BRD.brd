# Allegro board PROC101C_BRD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_MAIN_UART1_RX_3V3: length 81.1
  TOP w0.147: U23.E15 v1(96.26,73.5)
  L03_SIG1 w0.091: v1(151,37.99) 148.9,37.99 138.59,48.3 138.59,50.22 137.89,50.92 137.89,53.13 134.72,56.3 131.28,56.3 129.91,57.67 125.64,57.67 124.06,56.09 122.1,56.09 121.32,55.31 113.83,55.31 112.72,56.42 112.72,57.5 109.85,60.37 109.52,60.37 v1(109.19,60.04)
  L08_SIG2 w0.091: v1(109.19,60.04) 109.19,60.49 107.54,62.15 107.54,68.53 104.93,71.13 100.84,71.13 98.07,73.91 96.66,73.91 v1(96.26,73.5)
  BOTTOM w0.147: U89.8 151.8,38.29 151.5,37.99 v1(151,37.99)
SOC_MAIN_UART1_TX_3V3: length 85
  TOP w0.147: U23.E14 v1(96.26,74.3)
  L03_SIG1 w0.091: v1(152.4,37.23) 149.35,37.23 138.37,48.21 138.37,50.12 137.93,50.57 137.67,50.82 137.67,52.97 134.52,56.12 131.2,56.12 129.84,57.48 126.75,57.48 125.17,55.91 122.17,55.91 121.39,55.13 113.63,55.13 112.49,56.26 112.49,56.91 109.99,59.41 109.99,59.42 v1(109.73,59.68)
  L08_SIG2 w0.091: v1(109.73,59.68) 109.73,60.52 107.76,62.49 107.76,68.57 104.99,71.34 100.92,71.34 98.76,73.5 98.76,74.11 98.16,74.7 96.66,74.7 v1(96.26,74.3)
  BOTTOM w0.147: U89.6 152.6,38.24 152.66,38.18 152.66,37.48 v1(152.4,37.23) 152.4,36.77 152.25,36.63 R609.2
SOC_MAIN_UART3_RX_3V3: length 80
  TOP w0.147: U23.D16 v1(97.06,72.7)
  L03_SIG1 w0.091: v1(150.75,39.13) 148.46,39.13 145.23,42.36 145.23,50.24 141.73,53.74 137.92,53.74 134.91,56.75 131.47,56.75 130.18,58.03 125.49,58.03 123.91,56.45 121.94,56.45 121.17,55.68 114.14,55.68 113.16,56.66 113.16,57.58 108.07,62.66 108.07,65.1 105.97,67.2 105.97,70.71 103.81,72.87 98.6,72.87 98.36,73.1 97.46,73.1 v1(97.06,72.7)
  BOTTOM w0.147: v1(150.75,39.13) 151.04,39.42 U89.9
SOC_MAIN_UART3_TX_3V3: length 82.6
  TOP w0.147: U23.E16 v1(96.26,72.7)
  L03_SIG1 w0.091: v1(108.56,60.43) 108.92,60.79 109.68,60.79 112.94,57.54 112.94,56.57 114.01,55.49 121.24,55.49 122.02,56.27 123.98,56.27 125.56,57.85 130.08,57.85 131.41,56.52 134.81,56.52 138.11,53.23 138.11,51.01 138.81,50.31 138.81,48.39 148.78,38.42 151.71,38.42 v1(152.15,37.99)
  L08_SIG2 w0.091: v1(96.26,72.7) 96.66,73.1 98.27,73.1 100.46,70.91 104.9,70.91 107.31,68.49 107.31,61.67 v1(108.56,60.43)
  BOTTOM w0.147: R610.2 151.54,37.39 v1(152.15,37.99) 152.2,38.04 U89.7
SOC_MMC0_CLK: length 21
  TOP w0.147: U23.G18 v1(94.66,71.1)
  L03_SIG1 w0.091: v1(94.66,71.1) 94.84,70.92 94.84,70.85 95.06,70.63 95.06,69.47 95.4,69.12 95.4,67.71 99.53,63.58 99.53,62.3 104.66,57.17 104.66,56.03 v1(104.39,55.77)
  BOTTOM w0.147: v1(104.39,55.77) 104.27,55.64 R404.2
SOC_MMC0_CMD: length 59.2
  TOP w0.147: v1(93.47,66.31) 93.47,66.72 92.74,67.46 92.74,68.54 92.66,68.62 U23.J21 ; v1(117.49,35.31) 117.62,35.17 U44.M5
  L03_SIG1 w0.091: v1(117.49,35.31) 115.46,35.31 113.28,37.48 113.28,42.76 113.84,43.32 113.84,44.59 112.82,45.61 112.35,45.61 112.27,45.53 112.27,44.77 112.19,44.69 112.07,44.69 111.99,44.77 111.99,45.53 111.91,45.61 111.8,45.61 111.72,45.53 111.72,44.77 111.64,44.69 111.53,44.69 111.44,44.77 111.44,45.53 111.36,45.61 110.22,45.61 110.14,45.53 110.14,44.8 110.06,44.72 109.94,44.72 109.86,44.8 109.86,45.53 109.78,45.61 109.67,45.61 109.59,45.53 109.59,44.8 109.51,44.72 109.39,44.72 109.31,44.8 109.31,45.53 109.23,45.61 109.12,45.61 109.04,45.53 109.04,44.8 108.96,44.72 108.84,44.72 108.76,44.8 108.76,45.53 108.68,45.61 107.44,45.61 102.21,50.84 102.21,55.95 96.1,62.06 96.1,62.69 93.92,64.87 93.3,64.87 93.05,65.12 93.05,65.88 v1(93.47,66.31)
  BOTTOM w0.147: v1(117.49,35.31) 117.13,34.95 R457.2
SOC_MMC0_DAT0: length 60.2
  TOP w0.147: v1(93.47,65.29) 93.47,65.67 92.96,66.17 92.96,66.82 92.45,67.33 92.45,68.42 92.26,68.62 92.26,69.5 U23.K20 ; R161.2 115.65,44.95 115.18,44.47 115.18,43.95 v1(114.55,43.32) 116.34,41.53 116.34,41.18 116.62,40.9 U44.A3
  L03_SIG1 w0.091: v1(114.55,43.32) 114.06,43.81 114.06,46.61 113.61,47.06 112.48,47.06 112.39,46.98 112.39,46.25 112.31,46.17 112.2,46.17 112.12,46.25 112.12,46.98 112.04,47.06 111.93,47.06 111.85,46.98 111.85,46.25 111.77,46.17 111.65,46.17 111.57,46.25 111.57,46.98 111.49,47.06 111.38,47.06 111.3,46.98 111.3,46.25 111.22,46.17 111.1,46.17 111.02,46.25 111.02,46.98 110.94,47.06 110.83,47.06 110.75,46.98 110.75,46.25 110.67,46.17 110.55,46.17 110.47,46.25 110.47,46.98 110.39,47.06 110.28,47.06 110.2,46.98 110.2,46.25 110.12,46.17 110.01,46.17 109.93,46.25 109.93,46.98 109.85,47.06 109.73,47.06 109.65,46.98 109.65,46.25 109.57,46.17 109.46,46.17 109.38,46.25 109.38,46.98 109.3,47.06 109.18,47.06 109.1,46.98 109.1,46.25 109.02,46.17 108.91,46.17 108.83,46.25 108.83,46.98 108.75,47.06 108.63,47.06 108.55,46.98 108.55,46.25 108.47,46.17 108.36,46.17 108.28,46.25 108.28,46.98 108.2,47.06 108.09,47.06 108.01,46.98 108.01,46.25 107.93,46.17 107.81,46.17 107.73,46.25 107.73,46.98 107.65,47.06 107.43,47.06 102.43,52.06 102.43,55.99 96.29,62.13 96.29,63.04 94.03,65.29 v1(93.47,65.29)
SOC_MMC0_DAT1: length 58.2
  TOP w0.147: U44.A4 117.12,43.47 v1(117.98,44.33) R163.2 ; U23.J20 93.06,69.5 93.06,68.67 93.03,68.63 93.03,67.77 v1(93.47,67.32)
  L03_SIG1 w0.091: v1(93.47,67.32) 96.47,64.33 96.47,62.21 102.65,56.02 102.65,52.52 107.02,48.15 108.51,48.15 108.59,48.23 108.59,48.62 108.67,48.7 108.78,48.7 108.87,48.62 108.87,48.23 108.95,48.15 109.06,48.15 109.14,48.23 109.14,48.62 109.22,48.7 109.33,48.7 109.41,48.62 109.41,48.23 109.49,48.15 109.61,48.15 109.69,48.23 109.69,48.62 109.77,48.7 109.88,48.7 109.96,48.62 109.96,48.23 110.04,48.15 110.16,48.15 110.24,48.23 110.24,48.62 110.32,48.7 110.43,48.7 110.51,48.62 110.51,48.23 110.59,48.15 110.7,48.15 110.79,48.23 110.79,48.62 110.87,48.7 110.98,48.7 111.06,48.62 111.06,48.23 111.14,48.15 111.25,48.15 111.33,48.23 111.33,48.62 111.41,48.7 111.53,48.7 111.61,48.62 111.61,48.23 111.69,48.15 111.8,48.15 111.88,48.23 111.88,48.62 111.96,48.7 112.08,48.7 112.16,48.62 112.16,48.23 112.24,48.15 112.35,48.15 112.43,48.23 112.43,48.62 112.51,48.7 112.63,48.7 112.71,48.62 112.71,48.23 112.79,48.15 112.9,48.15 112.98,48.23 112.98,48.62 113.06,48.7 113.17,48.7 113.25,48.62 113.25,48.23 113.33,48.15 114.16,48.15 114.38,47.93 114.5,47.93 114.88,48.31 115,48.31 115.08,48.23 115.08,48.12 114.69,47.73 114.69,47.62 114.77,47.54 114.88,47.54 115.27,47.92 115.38,47.92 115.46,47.84 115.46,47.73 115.08,47.34 115.08,47.23 115.16,47.15 115.27,47.15 115.66,47.53 115.77,47.53 115.85,47.45 115.85,47.34 115.47,46.96 115.47,46.84 115.55,46.76 115.66,46.76 116.05,47.15 116.16,47.15 116.24,47.07 116.24,46.95 115.85,46.57 115.85,46.45 v1(117.98,44.33)
SOC_MMC0_DAT2: length 59.7
  TOP w0.147: R165.2 120.23,44.95 119.75,44.47 119.75,44.13 v1(119.13,43.5) 119.13,42.53 117.62,41.03 U44.A5 ; U23.J18 v1(93.06,71.1)
  L03_SIG1 w0.091: v1(93.06,71.1) 92.66,70.71 92.66,69.91 94.34,68.24 94.34,67.27 96.7,64.91 96.7,62.29 102.88,56.12 102.88,52.61 105.76,49.73 107.54,49.73 108.32,48.95 108.68,48.95 108.76,49.03 108.76,49.56 108.84,49.64 108.95,49.64 109.03,49.56 109.03,49.03 109.11,48.95 109.22,48.95 109.31,49.03 109.31,49.56 109.39,49.64 109.5,49.64 109.58,49.56 109.58,49.03 109.66,48.95 109.77,48.95 109.85,49.03 109.85,49.56 109.93,49.64 110.05,49.64 110.13,49.56 110.13,49.03 110.21,48.95 110.32,48.95 110.4,49.03 110.4,49.56 110.48,49.64 110.6,49.64 110.68,49.56 110.68,49.03 110.76,48.95 110.87,48.95 110.95,49.03 110.95,49.56 111.03,49.64 111.15,49.64 111.23,49.56 111.23,49.03 111.31,48.95 111.42,48.95 111.5,49.03 111.5,49.56 111.58,49.64 111.69,49.64 111.77,49.56 111.77,49.03 111.85,48.95 111.97,48.95 112.05,49.03 112.05,49.56 112.13,49.64 112.24,49.64 112.32,49.56 112.32,49.03 112.4,48.95 112.52,48.95 112.6,49.03 112.6,49.56 112.68,49.64 112.79,49.64 112.87,49.56 112.87,49.03 112.95,48.95 115.1,48.95 118.42,45.63 118.42,44.22 v1(119.13,43.5)
SOC_MMC0_DAT3: length 58.5
  TOP w0.094: 115.85,40.61 115.85,40.49 115.86,40.48 115.86,40.24 115.87,40.23 115.87,40.1 U44.B2
  TOP w0.147: 115.85,40.61 113.41,43.06 v1(113.41,44.33) R159.2 ; U23.J17 v1(93.06,71.9)
  L03_SIG1 w0.091: v1(93.06,71.9) 92.66,71.51 92.08,71.51 91.86,71.28 91.86,70.12 92.81,69.17 92.81,64.04 93.28,63.57 94.89,63.57 95.92,62.54 95.92,61.98 101.99,55.91 101.99,50.79 108.45,44.33 109.73,44.33 109.81,44.25 109.81,43.26 109.89,43.18 110,43.18 110.08,43.26 110.08,44.25 110.16,44.33 110.28,44.33 110.36,44.25 110.36,43.26 110.44,43.18 110.55,43.18 110.63,43.26 110.63,44.25 110.71,44.33 110.83,44.33 110.91,44.25 110.91,43.26 110.99,43.18 111.1,43.18 111.18,43.26 111.18,44.25 111.26,44.33 111.38,44.33 111.46,44.25 111.46,43.26 111.54,43.18 111.65,43.18 111.73,43.26 111.73,44.25 111.81,44.33 111.92,44.33 112,44.25 112,43.26 112.09,43.18 112.2,43.18 112.28,43.26 112.28,44.25 112.36,44.33 v1(113.41,44.33)
SOC_MMC0_DAT4: length 58.3
  TOP w0.094: 116.37,40.6 116.37,40.1 U44.B3
  TOP w0.147: 116.37,40.6 113.92,43.05 113.92,43.7 v1(114.55,44.33) R160.2 ; U23.H17 v1(93.86,71.9)
  L03_SIG1 w0.091: v1(93.86,71.9) 94.26,71.51 94.26,69.65 94.96,68.94 94.96,67.53 99.06,63.43 99.06,62.15 103.54,57.67 103.54,52.88 105.48,50.94 115.1,50.94 119.97,46.06 119.97,43.43 119.36,42.81 116.07,42.81 v1(114.55,44.33)
SOC_MMC0_DAT5: length 58.2
  TOP w0.094: 116.87,40.6 116.87,40.1 U44.B4
  TOP w0.147: 116.87,40.6 116.87,41.08 116.66,41.29 116.66,43.7 116.84,43.87 v1(116.84,44.33) R162.2 ; U23.H19 v1(93.86,70.3)
  L03_SIG1 w0.091: v1(93.86,70.3) 93.86,69.73 94.74,68.85 94.74,67.43 98.81,63.37 98.81,62.09 103.32,57.58 103.32,52.79 105.39,50.72 105.89,50.72 105.97,50.64 105.97,50.25 106.05,50.16 106.16,50.16 106.24,50.25 106.24,50.64 106.32,50.72 106.44,50.72 106.52,50.64 106.52,50.25 106.6,50.16 106.71,50.16 106.79,50.25 106.79,50.64 106.87,50.72 106.99,50.72 107.07,50.64 107.07,50.25 107.15,50.16 107.26,50.16 107.34,50.25 107.34,50.64 107.42,50.72 107.54,50.72 107.62,50.64 107.62,50.25 107.7,50.16 107.81,50.16 107.89,50.25 107.89,50.64 107.97,50.72 108.08,50.72 108.16,50.64 108.16,50.25 108.24,50.16 108.36,50.16 108.44,50.25 108.44,50.64 108.52,50.72 108.63,50.72 108.71,50.64 108.71,50.25 108.79,50.16 108.91,50.16 108.99,50.25 108.99,50.64 109.07,50.72 115.01,50.72 119.76,45.96 119.76,43.52 119.31,43.07 118.1,43.07 v1(116.84,44.33)
SOC_MMC0_DAT6: length 58.4
  TOP w0.094: U44.B5 117.37,40.1 117.37,40.6
  TOP w0.147: 117.37,40.6 117.37,41.26 118.58,42.47 118.58,43.78 v1(119.12,44.33) R164.2 ; U23.H18 v1(93.86,71.1)
  L03_SIG1 w0.091: v1(119.12,44.33) 119.12,45.95 115.14,49.93 113.99,49.93 113.91,50.01 113.91,50.45 113.83,50.53 113.72,50.53 113.64,50.45 113.64,50.01 113.56,49.93 113.45,49.93 113.36,50.01 113.36,50.45 113.28,50.53 113.17,50.53 113.09,50.45 113.09,50.01 113.01,49.93 112.9,49.93 112.82,50.01 112.82,50.45 112.74,50.53 112.62,50.53 112.54,50.45 112.54,50.01 112.46,49.93 112.35,49.93 112.27,50.01 112.27,50.45 112.19,50.53 112.07,50.53 111.99,50.45 111.99,50.01 111.91,49.93 111.8,49.93 111.72,50.01 111.72,50.45 111.64,50.53 111.52,50.53 111.44,50.45 111.44,50.01 111.36,49.93 111.25,49.93 111.17,50.01 111.17,50.45 111.09,50.53 110.98,50.53 110.9,50.45 110.9,50.01 110.82,49.93 110.7,49.93 110.62,50.01 110.62,50.45 110.54,50.53 110.43,50.53 110.35,50.45 110.35,50.01 110.27,49.93 110.15,49.93 110.07,50.01 110.07,50.45 109.99,50.53 109.88,50.53 109.8,50.45 109.8,50.01 109.72,49.93 105.87,49.93 103.1,52.7 103.1,56.43 102.42,57.11 102.42,58.09 101.78,58.72 100.58,58.72 96.9,62.4 96.9,64.99 94.54,67.35 94.54,68.66 93.46,69.74 93.46,70.71 v1(93.86,71.1)
SOC_MMC0_DAT7: length 58.4
  TOP w0.094: 117.87,40.6 117.87,40.1 U44.B6
  TOP w0.147: U23.G17 v1(94.66,71.9) ; R166.2 121.41,44.6 v1(121.77,44.24) 119.67,42.14 119.16,42.14 117.95,40.92 117.95,40.68 117.87,40.6
  L03_SIG1 w0.091: v1(121.77,44.24) 122.3,44.77 122.3,46.4 121.14,47.56 121.03,47.56 120.84,47.38 120.73,47.38 120.65,47.46 120.65,47.57 120.83,47.76 120.83,47.87 120.75,47.95 120.64,47.95 120.45,47.76 120.34,47.76 120.26,47.84 120.26,47.96 120.45,48.15 120.45,48.26 120.37,48.34 120.25,48.34 120.06,48.15 119.95,48.15 119.87,48.23 119.87,48.35 120.06,48.53 120.06,48.65 119.98,48.73 119.86,48.73 119.68,48.54 119.56,48.54 119.48,48.62 119.48,48.73 119.67,48.92 119.67,49.04 119.59,49.12 119.48,49.12 119.29,48.93 119.17,48.93 119.09,49.01 119.09,49.12 119.28,49.31 119.28,49.42 119.2,49.5 119.09,49.5 118.9,49.32 118.79,49.32 118.71,49.4 118.71,49.51 118.89,49.7 118.89,49.81 118.81,49.89 118.7,49.89 118.51,49.7 118.4,49.7 118.32,49.78 118.32,49.9 118.51,50.09 118.51,50.2 118.43,50.28 118.31,50.28 118.12,50.09 118.01,50.09 117.93,50.17 117.93,50.29 118.12,50.47 118.12,50.59 118.04,50.67 117.92,50.67 117.74,50.48 117.62,50.48 117.54,50.56 117.54,50.67 117.73,50.86 117.73,50.98 117.58,51.13 117.32,51.13 116.85,51.6 108.56,51.6 104.88,55.28 104.88,57.26 99.76,62.39 99.76,63.67 95.86,67.56 95.86,70.14 95.86,70.15 95.86,70.47 95.62,70.71 95.29,70.71 95.06,70.94 95.06,71.5 v1(94.66,71.9)
SOC_MMC0_DS: length 54.5
  TOP w0.147: U23.G19 v1(94.66,70.3)
  L03_SIG1 w0.091: v1(94.66,70.3) 94.66,69.56 95.18,69.03 95.18,67.62 99.31,63.49 99.31,62.2 103.79,57.73 103.79,52.94 105.58,51.16 115.19,51.16 120.16,46.19 120.16,43.39 120.16,43.35 119.44,42.63 116.15,42.63 113.75,40.23 v1(113.75,37.95)
  BOTTOM w0.147: R446.1 v1(113.75,37.95)
SOC_OSPI_DQ0: length 46.4
  TOP w0.147: U23.M19 v1(89.86,70.3)
  L03_SIG1 w0.091: v1(89.86,70.3) 90.16,70.01 90.16,66.09 90.27,65.98 90.27,65.04 90.01,64.78 90.01,62.97 91.71,61.27 94.9,61.27 96.94,59.23 96.94,58.09 97.13,57.9 97.13,57.79 96.93,57.6 96.93,57.48 97.01,57.4 97.13,57.4 97.32,57.6 97.43,57.6 97.51,57.51 97.51,57.4 97.32,57.2 97.32,57.09 97.4,57.01 97.51,57.01 97.71,57.21 97.82,57.21 97.9,57.13 97.9,57.01 97.7,56.82 97.7,56.7 97.78,56.62 97.9,56.62 98.1,56.82 98.21,56.82 98.29,56.74 98.29,56.63 98.09,56.43 98.09,56.31 98.17,56.23 98.29,56.23 98.48,56.43 98.6,56.43 98.68,56.35 98.68,56.24 98.48,56.04 98.48,55.93 98.56,55.85 98.67,55.85 98.87,56.04 98.98,56.04 99.07,55.96 99.07,55.85 98.87,55.65 98.87,55.54 98.95,55.46 99.06,55.46 99.26,55.66 99.37,55.66 99.45,55.57 99.45,55.46 99.26,55.26 99.26,55.15 99.34,55.07 99.45,55.07 99.65,55.27 99.76,55.27 99.9,55.12 99.9,48.8 99.72,48.61 99.72,47.73 100.82,46.63 100.82,37.41 v1(100.35,36.94)
  BOTTOM w0.147: R440.2 v1(100.35,36.94)
SOC_OSPI_DQ1: length 47.1
  TOP w0.147: U23.M18 v1(89.86,71.1)
  L03_SIG1 w0.091: v1(89.86,71.1) 89.46,70.71 89.46,68.39 89.18,68.11 89.18,67.18 88.65,66.65 88.65,65.66 89.47,64.83 89.47,62.87 91.33,61.01 91.33,60.34 91.71,59.96 94.1,59.96 95.78,58.28 95.78,48.23 94.46,46.91 94.46,46.64 94.38,46.56 94.04,46.56 93.96,46.48 93.96,46.37 94.04,46.29 94.38,46.29 94.46,46.21 94.46,46.09 94.38,46.01 94.04,46.01 93.96,45.93 93.96,45.82 94.04,45.74 94.38,45.74 94.46,45.66 94.46,45.55 94.38,45.47 94.04,45.47 93.96,45.38 93.96,45.27 94.04,45.19 94.38,45.19 94.46,45.11 94.46,45 94.38,44.92 94.04,44.92 93.96,44.84 93.96,44.72 94.04,44.64 94.38,44.64 94.46,44.56 94.46,44.45 94.38,44.37 94.04,44.37 93.96,44.29 93.96,44.17 94.04,44.09 94.38,44.09 94.46,44.01 94.46,43.9 94.38,43.82 94.04,43.82 93.96,43.74 93.96,43.63 94.04,43.55 94.38,43.55 94.46,43.46 94.46,43.35 94.38,43.27 94.04,43.27 93.96,43.19 93.96,43.08 94.04,43 94.38,43 94.46,42.92 94.46,42.8 94.38,42.72 94.04,42.72 93.96,42.64 93.96,42.53 94.04,42.45 94.38,42.45 94.46,42.37 94.46,41.43 94.68,41.21 95.59,41.21 v1(96.01,40.78)
  BOTTOM w0.147: R433.2 93.36,40.82 93.92,41.38 95.42,41.38 v1(96.01,40.78)
SOC_OSPI_DQ2: length 47.5
  TOP w0.147: U23.M20 90.66,69.5 90.66,68.46 90.93,68.19 v1(90.93,67.07)
  L03_SIG1 w0.091: v1(105.66,44.46) 105.66,46.43 104.74,47.35 104.63,47.35 104.04,46.77 103.92,46.77 103.84,46.85 103.84,46.96 104.43,47.55 104.43,47.66 104.35,47.74 104.24,47.74 103.65,47.15 103.54,47.15 103.46,47.24 103.46,47.35 104.04,47.94 104.04,48.05 103.96,48.13 103.85,48.13 103.26,47.54 103.15,47.54 103.07,47.62 103.07,47.74 103.66,48.32 103.66,48.44 103.58,48.52 103.46,48.52 102.87,47.93 102.76,47.93 102.68,48.01 102.68,48.12 103.27,48.71 103.27,48.83 103.19,48.91 103.07,48.91 102.49,48.32 102.37,48.32 102.29,48.4 102.29,48.51 102.88,49.1 102.88,49.21 102.8,49.29 102.69,49.29 102.1,48.71 101.98,48.71 101.9,48.79 101.9,48.9 102.49,49.49 102.49,49.6 102.41,49.68 102.3,49.68 101.71,49.09 101.6,49.09 101.52,49.17 101.52,49.29 102.1,49.88 102.1,49.99 101.55,50.54 101.55,55.84 95.55,61.83 95.55,61.92 95.21,62.26 93.02,62.26 92.38,62.9 92.38,64.81 92.02,65.17 91.83,65.17 91.6,65.4 91.6,66.4 v1(90.93,67.07)
  BOTTOM w0.147: R423.2 v1(105.66,44.46)
SOC_OSPI_DQ3: length 47
  TOP w0.147: U23.M21 90.26,68.46 90.52,68.2 90.52,66.44 v1(91.17,65.79)
  L03_SIG1 w0.091: v1(105.66,43.07) 104.48,44.26 104.36,44.26 103.85,43.75 103.74,43.75 103.66,43.83 103.66,43.94 104.17,44.45 104.17,44.56 104.09,44.64 103.97,44.64 103.47,44.14 103.35,44.14 103.27,44.22 103.27,44.33 103.78,44.84 103.78,44.95 103.7,45.03 103.59,45.03 103.08,44.52 102.97,44.52 102.89,44.6 102.89,44.72 103.39,45.23 103.39,45.34 103.31,45.42 103.2,45.42 102.69,44.91 102.58,44.91 102.5,44.99 102.5,45.11 103,45.61 103,45.73 102.92,45.81 102.81,45.81 102.3,45.3 102.19,45.3 102.11,45.38 102.11,45.49 102.62,46 102.62,46.12 102.54,46.2 102.42,46.2 101.92,45.69 101.8,45.69 101.72,45.77 101.72,45.88 102.23,46.39 102.23,46.5 102.15,46.58 102.04,46.58 101.53,46.08 101.41,46.08 101.33,46.16 101.33,46.27 101.84,46.78 101.84,46.89 101.22,47.51 101.22,55.91 95.37,61.76 95.37,61.84 95.18,62.04 92.79,62.04 92.2,62.63 92.2,64.73 91.95,64.98 91.74,64.98 91.17,65.56 v1(91.17,65.79)
  BOTTOM w0.147: v1(105.66,43.07) 105.15,43.58 104.47,43.58 103.99,43.11 R425.2
SOC_OSPI_DQ4: length 48.3
  TOP w0.147: v1(88.32,67) 88.66,67.34 U23.P21
  L03_SIG1 w0.091: v1(100.2,42.05) 100.2,40.76 99.22,39.78 94.53,39.78 93.78,40.53 93.78,49.11 94.61,49.95 94.61,57.46 92.51,59.56 91.33,59.56 88.32,62.57 88.32,65.03 88.24,65.11 87.5,65.11 87.42,65.19 87.42,65.3 87.5,65.38 88.24,65.38 88.32,65.46 88.32,65.57 88.24,65.65 87.6,65.65 87.52,65.73 87.52,65.85 87.6,65.93 88.24,65.93 88.32,66.01 v1(88.32,67)
  BOTTOM w0.147: R432.2 103.99,41.63 103.44,41.08 101.18,41.08 v1(100.2,42.05)
SOC_OSPI_DQ5: length 46.9
  TOP w0.147: U23.P20 89.06,69.5 89.06,67.09 87.05,65.08 87.05,63.96 v1(87.37,63.64)
  L03_SIG1 w0.091: v1(99.08,36.94) 98.64,37.38 97.59,37.38 96.68,36.46 95.68,36.46 93.48,38.67 93.48,47.99 92.76,48.71 92.76,57.11 91.51,58.36 87.91,58.36 87.37,58.89 87.37,60.38 87.45,60.46 87.61,60.46 87.69,60.54 87.69,60.65 87.61,60.73 87.45,60.73 87.37,60.81 87.37,60.93 87.45,61.01 87.61,61.01 87.69,61.09 87.69,61.2 87.61,61.28 87.45,61.28 87.37,61.36 87.37,61.47 87.45,61.55 87.61,61.55 87.69,61.63 87.69,61.75 87.61,61.83 87.45,61.83 87.37,61.91 87.37,62.02 87.45,62.1 87.61,62.1 87.69,62.18 87.69,62.3 87.61,62.38 87.45,62.38 87.37,62.46 87.37,62.57 87.45,62.65 87.61,62.65 87.69,62.73 87.69,62.85 87.61,62.93 87.45,62.93 87.37,63.01 v1(87.37,63.64)
  BOTTOM w0.147: R441.2 v1(99.08,36.94)
SOC_OSPI_DQ6: length 47.7
  TOP w0.147: U23.N18 v1(89.06,71.1)
  L03_SIG1 w0.091: v1(97.81,36.94) 97.08,36.21 95.68,36.21 93.29,38.59 93.29,47.91 92.54,48.67 92.54,57.07 91.54,58.08 87.86,58.08 87.14,58.79 87.14,62.6 86.91,62.84 86.91,67.85 87.36,68.3 87.47,68.3 87.72,68.05 87.83,68.05 87.91,68.13 87.91,68.25 87.67,68.49 87.67,68.6 87.75,68.69 87.86,68.69 88.11,68.44 88.22,68.44 88.3,68.52 88.3,68.63 88.05,68.88 88.05,68.99 88.13,69.07 88.25,69.07 88.49,68.83 88.61,68.83 88.69,68.91 88.69,69.02 88.44,69.27 88.44,69.38 88.66,69.6 88.66,70.71 v1(89.06,71.1)
  BOTTOM w0.147: R442.2 v1(97.81,36.94)
SOC_OSPI_DQ7: length 48.6
  TOP w0.147: U23.M17 v1(89.86,71.9)
  L03_SIG1 w0.091: v1(89.86,71.9) 90.3,71.47 90.3,70.15 90.36,70.09 90.36,66.36 90.45,66.27 90.45,65.51 91.09,64.86 91.09,62.85 91.61,62.33 91.98,62.33 92.63,61.67 94.94,61.67 100.85,55.76 100.85,54.81 100.09,54.04 100.09,48.72 99.9,48.54 99.9,47.81 101.04,46.67 101.04,37.01 100.53,36.5 100.16,36.5 99.07,37.6 97.19,37.6 v1(96.54,36.94)
  BOTTOM w0.147: R443.2 v1(96.54,36.94)
SOC_POWER_MON_PORZ: length 65.5
  TOP w0.147: U41.1 v1(139.56,39.86)
  L08_SIG2 w0.091: v1(130.05,96.41) 130.05,87.9 136.65,81.29 136.65,69.48 140.46,65.67 140.46,41.54 139.56,40.64 v1(139.56,39.86)
  BOTTOM w0.147: v1(130.05,96.41) 129.9,96.26 R285.2 129.9,95.01 129.58,94.68 U76.4
SOC_SPI0_CLK: length 41
  TOP w0.147: U23.D13 v1(97.06,75.1)
  L03_SIG1 w0.091: v1(116.81,59.38) 116.31,59.88 116.31,65.41 114.77,66.95 114.77,72.5 111.97,75.3 103.21,75.3 102.73,75.78 99.11,75.78 98.57,76.32 97.71,76.32 97.46,76.07 97.46,75.56 97.06,75.16 v1(97.06,75.1)
  BOTTOM w0.147: v1(116.81,59.38) 116.19,59.38 116.12,59.45 TP77.1 115.37,58.67 115.88,58.16 R395.1 115.88,56.57 116.13,56.32 U83.2
SOC_SPI0_CS0: length 48.2
  TOP w0.147: U23.D12 v1(97.06,75.9)
  L03_SIG1 w0.091: v1(117.75,59.59) 116.72,60.62 116.72,65.58 115.22,67.08 115.22,72.68 112.16,75.74 103.47,75.74 102.36,76.85 97.63,76.85 97.06,76.28 v1(97.06,75.9)
  BOTTOM w0.147: U83.1 R399.1 TP80.1 111.89,56.17 112.62,56.9 112.62,57.66 115.04,60.07 117.27,60.07 v1(117.75,59.59)
SOC_SPI0_MISO: length 41.7
  TOP w0.147: U23.A14 100.24,74.7 100.5,74.44 100.78,74.44 v1(101.4,73.82)
  L03_SIG1 w0.091: v1(101.4,73.82) 102.76,73.82 103.12,74.18 109.98,74.18 110.41,73.75 110.41,71.92 112.61,69.73 112.61,66.45 114.09,64.96 114.09,57.86 115.84,56.11 v1(120.6,56.11)
  BOTTOM w0.147: U83.4 R398.1 TP79.1 121.03,55.68 v1(120.6,56.11)
SOC_SPI0_MOSI: length 36
  TOP w0.147: U23.A13 100.27,75.5 100.28,75.52 101.02,75.52 v1(101.47,75.07)
  L03_SIG1 w0.091: v1(116.2,58.69) 115.42,59.48 115.42,64.41 113.72,66.11 113.72,72.74 111.6,74.86 102.89,74.86 102.67,74.64 101.91,74.64 v1(101.47,75.07)
  BOTTOM w0.147: v1(116.2,58.69) 116.25,58.64 116.66,58.64 116.68,58.66 TP76.1 117.19,58.16 117.04,58.01 R394.1 117.04,56.57 116.78,56.32 U83.3
SOC_SPI1_CLK: length 114.2
  TOP w0.147: J2.C1 v1(74.55,129.81) ; U23.C14 v1(97.86,74.3)
  L03_SIG1 w0.091: v1(121.28,109.87) 120.18,109.87 116.18,113.87 96.57,113.87 94.18,116.26 94.18,117.78 88.46,123.5 85.39,123.5 82.95,125.94 79.46,125.94 75.59,129.81 v1(74.55,129.81) ; v1(97.86,74.3) 99.09,73.07 101.56,73.07 101.56,73.07 105.28,73.07 v1(105.61,73.4)
  L08_SIG2 w0.091: v1(121.28,109.87) 120.3,108.89 120.3,88.24 118.02,85.96 118.02,77.02 114.03,73.04 105.97,73.04 v1(105.61,73.4)
SOC_SPI1_CS0: length 108.6
  TOP w0.147: J2.D1 v1(74.55,131.08) ; U23.B14 98.66,75.1 99.97,75.1 100,75.07 v1(100.46,75.07)
  L03_SIG1 w0.091: v1(74.55,131.08) 75.44,131.08 76.84,129.68 76.84,129.19 79.64,126.39 83.13,126.39 85.58,123.94 88.55,123.94 93.86,118.62 114.31,118.62 v1(120.27,112.66)
  L08_SIG2 w0.091: v1(120.27,112.66) 119.64,112.03 119.64,88.53 114.48,83.37 114.48,82.4 113.03,80.95 113.03,77.66 110.89,75.52 100.9,75.52 v1(100.46,75.07)
SOC_SPI1_CS1: length 118.8
  TOP w0.147: J2.D2 v1(73.28,131.08) ; U23.D14 v1(97.06,74.3)
  L03_SIG1 w0.091: v1(97.06,74.3) 97.29,74.3 97.69,74.7 98.02,74.7 99.33,73.39 102.59,73.39 103.13,73.93 105.71,73.93 106.6,73.04 107.44,73.04 v1(107.95,72.53) ; v1(122.05,109.74) 121.4,110.39 120.29,110.39 116.58,114.09 96.6,114.09 94.36,116.34 94.36,117.86 88.54,123.68 85.52,123.68 83.04,126.16 79.55,126.16 75.27,130.44 73.91,130.44 v1(73.28,131.08)
  L08_SIG2 w0.091: v1(107.95,72.53) 108.59,72.53 108.91,72.86 114.11,72.86 118.24,76.99 118.24,85.87 120.52,88.15 120.52,107.58 122.05,109.1 v1(122.05,109.74)
SOC_SPI1_MISO: length 89.3
  TOP w0.147: v1(106.68,81.29) 106.68,80.41 103.76,77.48 103.76,75.06 101.81,73.11 101.02,73.11 100.23,73.9 U23.A15 ; J2.B1 v1(74.55,128.54)
  L03_SIG1 w0.091: v1(74.55,128.54) 71.88,125.87 71.88,120.39 73,119.27 73,117.29 74.65,115.65 75.39,115.65 78.3,112.74 97.65,112.74 107.38,103.01 107.38,82 v1(106.68,81.29)
SOC_SPI1_MOSI: length 90.5
  TOP w0.147: v1(105.28,80.64) 105.28,79.43 103.46,77.61 103.46,75.18 101.68,73.4 101.13,73.4 100.23,74.3 98.66,74.3 U23.B15 ; J2.B2 v1(73.28,128.54)
  L03_SIG1 w0.091: v1(105.28,80.64) 107.16,82.52 107.16,102.92 97.56,112.51 78.2,112.51 75.29,115.42 73.85,115.42 72.04,117.23 72.04,118.14 70.89,119.29 70.89,126.15 v1(73.28,128.54)
SOC_TCK: length 87.9
  TOP w0.147: U23.B11 98.66,77.5 100.52,77.5 100.54,77.49 100.88,77.49 100.9,77.5 101.11,77.5 v1(101.6,77.99) ; v1(126.16,60.42) 126.48,60.09 126.48,58.77 124.18,56.46 121.87,56.46 120.95,55.55 117.32,55.55 115.66,53.89 111.63,53.89 108.16,50.42 100.85,50.42 99.55,51.72 97.57,51.72 95.95,53.34 R147.2
  L03_SIG1 w0.091: v1(126.16,60.42) 123.19,60.42 123.06,60.55 118.74,60.55 117.34,61.94 117.34,65.78 115.88,67.25 115.88,72.97 111.31,77.55 102.05,77.55 v1(101.6,77.99)
  BOTTOM w0.147: R506.2 126.21,60.37 v1(126.16,60.42)
SOC_TDI: length 91.8
  TOP w0.147: U23.C11 v1(97.86,77.5) ; v1(125.43,59.59) 124.92,59.08 120.02,59.08 115.41,54.48 111.36,54.48 107.89,51.01 101.09,51.01 99.79,52.31 97.81,52.31 95.93,54.19 86.31,54.19 85.23,53.11 85.23,51.87 85.69,51.41 U37.7
  L03_SIG1 w0.091: v1(125.43,59.59) 125.06,59.22 122.89,59.22 122.87,59.2 119.33,59.2 116.94,61.6 116.94,65.67 115.44,67.17 115.44,72.77 112.25,75.96 103.56,75.96 102.45,77.07 98.29,77.07 v1(97.86,77.5)
  BOTTOM w0.147: U98.4 126.32,58.7 125.97,59.05 125.96,59.05 v1(125.43,59.59)
SOC_TDO: length 84.1
  TOP w0.147: U46.2 v1(90.48,33.03) ; U56.2 120.3,50.62 120.44,50.48 v1(120.45,50.48)
  L03_SIG1 w0.091: v1(120.45,50.48) 117.51,53.42 110.54,53.42 107.72,56.24 107.72,56.95 107.19,57.48 107.19,64.82 104.48,67.53 104.48,70.83 v1(103.43,71.87)
  BOTTOM w0.147: R323.1 102.09,75.32 102,75.22 102,73.76 103.43,72.33 v1(103.43,71.87) ; v1(120.45,50.48) 120.45,49.71 117.29,46.55 117.29,46.35 117.02,46.09 116.83,46.09 115.21,44.48 115.21,42.88 113.21,40.87 113.21,37.11 110.39,34.29 110.39,34.14 109.67,33.43 102.06,33.43 99.2,36.28 94.02,36.28 93.01,35.28 92.72,35.28 v1(90.48,33.03)
SOC_TMS: length 104.5
  TOP w0.147: U37.6 86.19,51.93 85.69,52.43 85.69,53.14 86.44,53.89 95.81,53.89 97.69,52.01 99.67,52.01 100.97,50.71 108.02,50.71 111.5,54.18 115.53,54.18 118.98,57.63 124.66,57.63 125.95,58.92 125.95,59.78 125.65,60.07 125.65,60.58 v1(126.21,61.14) ; U23.C12 v1(97.86,75.9)
  L03_SIG1 w0.091: v1(126.21,61.14) 127.51,61.14 128.35,60.3 128.35,59.49 127.28,58.42 125.36,58.42 124.68,57.74 118.32,57.74 118.19,57.61 117.47,57.61 116.99,58.09 116.99,58.6 115.95,59.64 115.95,65.51 114.55,66.91 114.55,72.4 111.88,75.08 103.12,75.08 102.62,75.58 98.93,75.58 98.61,75.9 v1(97.86,75.9)
  BOTTOM w0.147: U98.6 127.32,58.63 127.43,58.75 127.43,60.76 127.05,61.14 v1(126.21,61.14)
SOC_TRST#: length 97.3
  TOP w0.147: U23.D11 v1(97.06,77.5) ; v1(127.91,59.74) 127.91,58.68 125.22,55.98 121.89,55.98 121.01,55.09 117.4,55.09 115.86,53.56 111.73,53.56 108.3,50.12 100.73,50.12 99.42,51.42 97.44,51.42 96.04,52.83 87.91,52.83 87.46,52.38 87.46,51.96 87.19,51.69 U37.4
  L03_SIG1 w0.091: v1(127.91,59.74) 126.09,59.74 125.81,60.02 125.02,60.02 124.69,59.69 120.32,59.69 119.74,60.27 118.66,60.27 117.16,61.78 117.16,61.93 117.16,65.71 115.66,67.21 115.66,72.88 112.36,76.18 103.65,76.18 102.55,77.29 98.87,77.29 98.26,77.9 97.46,77.9 v1(97.06,77.5)
  BOTTOM w0.147: R322.1 98.77,77.38 98.29,76.9 97.66,76.9 v1(97.06,77.5) ; v1(127.91,59.74) 127.91,58.83 127.82,58.73 U98.7
SOC_USB0_VBUS: length 104.1
  TOP w0.147: U23.T14 v1(86.66,74.3)
  L08_SIG2 w0.091: v1(6.91,41.9) 21.47,56.46 43.64,56.46 46.99,59.82 46.99,62.03 47.35,62.38 47.35,62.95 61.55,77.15 74.95,77.15 76.48,75.63 76.5,75.63 76.56,75.56 80.87,75.56 82.51,73.93 86.28,73.93 v1(86.66,74.3)
  BOTTOM w0.147: R436.1 7.35,38.26 5.95,39.66 R427.2 6.63,42.18 v1(6.91,41.9)
SOC_WARM_RESETZ: length 68
  TOP w0.147: TP70.1 124.59,29.61 124.59,27.7 v1(124.46,27.58) U50.2 ; U23.E18 v1(96.26,71.1)
  L03_SIG1 w0.091: v1(121.97,48.87) 121.2,48.87 119.84,50.23 119.84,50.41 117.6,52.65 107.89,52.65 105.1,55.44 105.1,57.35 99.98,62.48 99.98,63.76 96.66,67.08 96.66,70.59 96.26,70.99 v1(96.26,71.1)
  L08_SIG2 w0.091: v1(121.97,48.87) 122.45,48.39 122.45,46.74 125.04,44.15 125.04,28.16 v1(124.46,27.58)
  BOTTOM w0.147: R476.1 125.11,27.58 v1(124.46,27.58)
SUPERVISOR_DEBOUNCE_RSTN: length 37.6
  TOP w0.147: SW7.1 136.64,10.75 136.09,11.29 136.09,16.15 136.64,16.7 SW7.2 136.64,18.8 v1(136.42,19.01) ; U57.2 v1(122,21.55) ; v1(127.64,23.13) 128,23.49 Q9.2
  BOTTOM w0.147: v1(122,21.55) 122,22.19 122.94,23.13 v1(127.64,23.13) 127.64,24.27 127.89,24.53 129.16,24.53 129.67,25.03 132.33,25.03 133.48,23.89 133.48,20.51 134.98,19.01 v1(136.42,19.01) 136.73,18.71 D10.2 137.31,18.03 137.42,17.92 C468.2 139.21,17.92 139.25,17.96 R540.1
SUPERVISOR_MR_RSTN: length 76.6
  TOP w0.147: U57.4 v1(122.65,25.63)
  L08_SIG2 w0.091: v1(124.21,91.96) 121.35,89.11 121.35,73.42 121.35,73.42 121.35,65.52 121.64,65.23 121.64,56.87 122.45,56.06 122.45,49.02 125.4,46.08 125.4,27.61 123.42,25.63 v1(122.65,25.63)
  BOTTOM w0.147: U76.1 127.41,93.14 126.24,91.96 v1(124.21,91.96)
SYNC1_OUT_TP: length 68.9
  TOP w0.147: U23.D18 v1(97.06,71.1) ; v1(103.56,70.12) 104.13,69.55 104.13,68.99 105.38,67.73 111.18,67.73 111.48,68.04 113.01,68.04 115.1,70.13 115.1,79.22 v1(114.3,80.02)
  L03_SIG1 w0.091: v1(97.06,71.1) 100.49,71.1 101.74,69.86 103.29,69.86 v1(103.56,70.12)
  L08_SIG2 w0.091: v1(114.3,80.02) 114.94,80.66 114.94,83.2 120.08,88.35 120.08,111.34 120.96,112.23 120.96,112.47 J12.1
SYS_BOOTMODE0: length 70.4
  TOP w0.147: SW2.1 v1(83.19,20.77)
  L08_SIG2 w0.091: v1(83.19,20.77) 83.62,21.2 83.62,28.38 82.84,29.16 82.84,31.79 79.35,35.28 79.35,39.85 73.1,46.09 73.1,52.41 72.73,52.78 72.73,55.15 72.39,55.49 72.39,57.93 70.18,60.14 70.18,64.92 68.81,66.28 v1(68.81,66.72)
  BOTTOM w0.147: U96.1 94.6,21.06 92.23,18.68 85.76,18.68 83.68,20.77 v1(83.19,20.77) R529.1 ; v1(68.81,66.72) 69.31,67.22 U79.3
SYS_BOOTMODE1: length 71.4
  TOP w0.147: SW2.2 v1(84.46,20.77)
  L08_SIG2 w0.091: v1(84.46,20.77) 84.01,20.32 82.99,20.32 82.66,20.66 82.66,31.71 79.16,35.21 79.16,39.77 72.87,46.06 72.87,52.33 71.75,53.45 71.75,54.44 71.91,54.6 71.91,58.1 69.95,60.05 69.95,64.83 68.38,66.41 68.38,67.42 v1(68.81,67.86)
  BOTTOM w0.147: R519.1 v1(84.46,20.77) 86.24,18.98 92.1,18.98 93.85,20.73 93.85,21.97 94,22.11 U96.2 ; U79.4 v1(68.81,67.86)
SYS_BOOTMODE2: length 72.3
  TOP w0.147: SW2.3 v1(85.73,20.77)
  L08_SIG2 w0.091: v1(67.81,66.72) 68.16,66.38 68.16,66.31 69.27,65.2 69.27,61.54 68.83,61.1 68.83,58.04 70.61,56.26 70.61,54.27 72.69,52.2 72.69,45.99 78.98,39.69 78.98,35.13 82.47,31.64 82.47,20.56 82.93,20.11 85.06,20.11 v1(85.73,20.77)
  BOTTOM w0.147: v1(67.81,66.72) 68.31,67.22 U79.5 ; R514.1 v1(85.73,20.77) 87.22,19.27 91.98,19.27 93.56,20.85 93.56,22.33 93.85,22.61 U96.3
SYS_BOOTMODE3: length 72.9
  TOP w0.147: SW2.4 v1(87,20.77)
  L08_SIG2 w0.091: v1(87,20.77) 86.15,19.92 82.86,19.92 82.29,20.49 82.29,31.56 78.78,35.07 78.78,39.59 72.47,45.89 72.47,52.1 69.02,55.56 69.02,57.11 68.45,57.67 68.45,61.1 68.89,61.54 68.89,63.97 68.02,64.84 68.02,65.6 67.31,66.31 67.31,67.36 v1(67.81,67.86)
  BOTTOM w0.147: R510.1 v1(87,20.77) 88.19,19.57 91.86,19.57 93.26,20.97 93.26,22.53 93.85,23.11 U96.4 ; U79.6 v1(67.81,67.86)
SYS_BOOTMODE4: length 73
  TOP w0.147: SW2.5 v1(88.27,20.77)
  L08_SIG2 w0.091: v1(66.81,66.72) 66.81,66.28 67.8,65.3 67.8,62.27 68.12,61.94 68.12,55.59 71.45,52.27 71.45,46.6 78.56,39.49 78.56,35.04 82.11,31.48 82.11,20.41 82.78,19.74 87.24,19.74 v1(88.27,20.77)
  BOTTOM w0.147: U79.7 67.31,67.22 v1(66.81,66.72) ; U96.5 93.85,23.61 92.97,22.73 92.97,21.09 91.74,19.86 89.17,19.86 v1(88.27,20.77) R503.1
SYS_BOOTMODE5: length 74.4
  TOP w0.147: SW2.6 v1(89.53,20.77)
  L08_SIG2 w0.091: v1(89.53,20.77) 88.33,19.56 82.7,19.56 81.93,20.34 81.93,31.41 78.33,35 78.33,39.32 71.22,46.43 71.22,51.98 67.84,55.36 67.84,61.12 66.64,62.33 66.64,65.71 66.29,66.05 66.29,67.34 v1(66.81,67.86)
  BOTTOM w0.147: v1(89.53,20.77) 90.14,20.16 ; v1(89.53,20.77) 90.14,20.16 ; v1(89.53,20.77) R498.1 ; 90.14,20.16 91.57,20.16 92.67,21.26 92.67,22.94 93.85,24.11 U96.6 ; U79.8 v1(66.81,67.86)
SYS_BOOTMODE6: length 73.9
  TOP w0.147: SW2.7 v1(90.8,20.77)
  L08_SIG2 w0.091: v1(65.81,66.72) 65.81,66.03 66.4,65.44 66.4,62.13 67.62,60.92 67.62,55.26 71,51.88 71,46.34 78.11,39.23 78.11,34.96 81.74,31.33 81.74,20.26 82.63,19.37 89.41,19.37 v1(90.8,20.77)
  BOTTOM w0.147: U96.7 93.43,24.61 92.35,23.54 92.35,21.63 91.49,20.77 v1(90.8,20.77) R489.1 ; U79.9 66.31,67.22 v1(65.81,66.72)
SYS_BOOTMODE7: length 76
  TOP w0.147: SW2.8 92.07,22.98 v1(91.77,23.28)
  L08_SIG2 w0.091: v1(91.77,23.28) 91.77,21.02 89.94,19.19 82.55,19.19 81.56,20.18 81.56,31.26 77.89,34.92 77.89,39.14 70.78,46.25 70.78,51.79 66.6,55.97 66.6,57.38 66.72,57.5 66.72,59.79 65.53,60.97 65.53,65.8 65.38,65.96 65.38,67.42 v1(65.81,67.86)
  BOTTOM w0.147: R474.1 90.78,23.46 90.83,23.41 90.83,23.41 90.96,23.28 v1(91.77,23.28) 91.77,23.54 93.35,25.11 U96.8 ; U79.10 v1(65.81,67.86)
SYS_BOOTMODE8: length 61
  TOP w0.147: SW3.1 v1(102.95,23.13)
  L08_SIG2 w0.091: v1(102.95,23.13) 93.48,32.59 88.28,32.59 86.03,34.84 86.03,39.87 77.29,48.61 v1(77.29,51.83)
  BOTTOM w0.147: R473.1 104.24,23.48 103.89,23.13 v1(102.95,23.13) 102.64,23.43 102.64,26.52 100.54,28.62 97.35,28.62 95.4,26.66 U96.9 ; U81.3 76.68,53.1 76.83,52.95 76.83,52.29 v1(77.29,51.83)
SYS_BOOTMODE9: length 66.2
  TOP w0.147: SW3.2 v1(104.22,20.84)
  L08_SIG2 w0.091: v1(76.29,52.85) 76.73,52.41 76.73,48.86 85.81,39.78 85.81,34.75 88.16,32.4 93.34,32.4 101.73,24.02 101.73,21.96 102.84,20.84 v1(104.22,20.84)
  BOTTOM w0.147: v1(76.29,52.85) 76.18,52.96 U81.4 ; R488.1 v1(104.22,20.84) 102.93,20.84 102.3,21.47 102.3,26.44 100.42,28.32 97.56,28.32 95.9,26.66 U96.10
SYS_BOOTMODE10: length 69.7
  TOP w0.147: SW3.3 v1(105.49,20.84)
  L08_SIG2 w0.091: v1(76.29,51.83) 76.29,51.39 76.28,51.38 76.28,48.99 85.59,39.69 85.59,34.66 89.56,30.69 94.8,30.69 101.54,23.94 101.54,21.8 103.42,19.92 104.56,19.92 v1(105.49,20.84)
  BOTTOM w0.147: R497.1 v1(105.49,20.84) 104.83,20.18 103.17,20.18 102.01,21.35 102.01,26.32 100.3,28.03 97.76,28.03 96.4,26.67 U96.11 ; v1(76.29,51.83) 75.75,52.38 75.75,53.15 75.68,53.22 U81.5
SYS_BOOTMODE11: length 72.3
  TOP w0.147: SW3.4 v1(106.76,20.84)
  L08_SIG2 w0.091: v1(75.29,52.85) 75.73,52.41 75.73,49.23 85.37,39.59 85.37,34.57 89.47,30.46 94.76,30.46 101.36,23.87 101.36,21.72 103.35,19.73 105.65,19.73 v1(106.76,20.84)
  BOTTOM w0.147: U81.6 75.18,52.96 v1(75.29,52.85) ; U96.12 96.9,26.65 97.99,27.73 100.18,27.73 101.71,26.2 101.71,21.23 103.05,19.89 105.8,19.89 v1(106.76,20.84) R502.1
SYS_BOOTMODE12: length 75.1
  TOP w0.147: SW3.5 v1(108.03,20.84)
  L08_SIG2 w0.091: v1(75.29,51.83) 75.29,49.36 85.15,39.5 85.15,34.48 89.38,30.24 94.73,30.24 101.06,23.91 101.06,21.39 102.9,19.55 106.73,19.55 v1(108.03,20.84)
  BOTTOM w0.147: v1(75.29,51.83) 74.75,52.38 74.75,53.15 74.68,53.22 U81.7 ; U96.13 97.4,26.73 98.11,27.44 100.06,27.44 101.42,26.08 101.42,21.11 102.93,19.59 106.78,19.59 v1(108.03,20.84) R509.1
SYS_BOOTMODE13: length 77.8
  TOP w0.147: SW3.6 v1(109.3,20.84)
  L08_SIG2 w0.091: v1(109.3,20.84) 107.76,19.3 102.89,19.3 100.87,21.32 100.87,23.84 94.69,30.02 89.29,30.02 84.93,34.38 84.93,39.41 74.73,49.61 74.73,52.41 v1(74.3,52.85)
  BOTTOM w0.147: U96.14 97.9,26.81 98.23,27.14 99.93,27.14 101.12,25.95 101.12,20.98 102.81,19.3 107.75,19.3 v1(109.3,20.84) R513.1 ; U81.8 74.18,52.96 v1(74.3,52.85)
SYS_BOOTMODE14: length 80.3
  TOP w0.147: SW3.7 v1(110.57,20.84)
  L08_SIG2 w0.091: v1(110.57,20.84) 108.84,19.12 102.74,19.12 100.69,21.17 100.69,23.76 94.65,29.8 89.2,29.8 84.71,34.29 84.71,39.32 74.3,49.73 v1(74.3,51.83)
  BOTTOM w0.147: U96.15 98.4,26.58 98.63,26.81 99.85,26.81 100.83,25.83 100.83,20.81 102.64,19 108.73,19 v1(110.57,20.84) R518.1 ; v1(74.3,51.83) 73.68,52.45 U81.9
SYS_BOOTMODE15: length 83.1
  TOP w0.147: SW3.8 v1(111.84,20.84)
  L08_SIG2 w0.091: v1(111.84,20.84) 111.84,20.44 110.34,18.94 102.57,18.94 100.51,21 100.51,23.69 94.61,29.58 89.11,29.58 84.48,34.2 84.48,39.28 75.95,47.82 74.63,47.82 73.35,49.09 73.35,52.78 v1(73.15,52.97)
  BOTTOM w0.147: U81.10 73.18,53 v1(73.15,52.97) ; U96.16 100.24,25.91 100.53,25.62 100.53,20.69 102.51,18.71 109.73,18.71 111.84,20.81 v1(111.84,20.84) R528.1
SYSBOOT_BUF_ENZ: length 3
  BOTTOM w0.147: R435.1 R434.1 108.98,39.18 108.97,39.16 U90.1
TCA6424_EXP_INT: length 2.3
  BOTTOM w0.147: U96.32 95.4,20 94.97,19.58 R533.1
TEST_GPIO1: length 67.3
  L08_SIG2 w0.091: v1(70.33,18.23) 71.39,19.29 74.3,19.29 79.46,14.13 92.55,14.13 94.4,15.98 105.49,15.98 106.51,17.01 113.35,17.01 116.95,20.61 117.32,20.61 122.54,20.61 123.84,21.9 123.84,22.55 124.15,22.86 126.38,22.86 126.79,22.45 v1(128.46,22.45)
  BOTTOM w0.147: Q17.1 v1(128.46,22.45) ; R545.1 v1(70.33,18.23) R523.1
TEST_GPIO2: length 36.7
  TOP w0.147: v1(69.19,18.23) 69.19,27.22 68.2,28.21 59.56,28.21 58.56,29.21 58.56,31.08 59.19,31.71 59.88,31.71 60.5,32.33 60.5,32.74 60.09,33.14 58.06,33.14 57.26,33.94 v1(51.82,33.94)
  BOTTOM w0.147: v1(51.82,33.94) 51.84,33.91 U91.14 ; R524.1 v1(69.19,18.23) R546.1
TEST_GPIO3: length 92
  TOP w0.147: TP41.1 68.05,18.66 v1(68.05,18.23) 68.05,15.48 66.17,13.6 54.74,13.6 53.59,12.46 J30.1
  L03_SIG1 w0.091: v1(111,36.84) 111.79,36.05 111.79,30.65 111.1,29.95 111.1,25.44 108.54,22.88 108.54,17.94 102.65,12.05 94.33,12.05 89.21,17.16 69.12,17.16 v1(68.05,18.23)
  BOTTOM w0.147: U90.2 110.39,37.61 110.41,37.62 R439.2 v1(111,36.84) ; R525.1 v1(68.05,18.23) R547.1
TEST_GPIO4: length 38.8
  TOP w0.147: TP40.1 66.9,18.91 v1(66.9,18.23)
  L08_SIG2 w0.091: v1(96.9,18.86) 92.39,14.35 79.55,14.35 74.39,19.51 68.18,19.51 v1(66.9,18.23)
  BOTTOM w0.147: v1(96.9,18.86) 97.4,19.36 U96.28 ; R526.1 v1(66.9,18.23) R548.1
TEST_LED1: length 71.3
  L08_SIG2 w0.091: v1(103.8,16.42) 103.02,16.42 98.82,20.62 94.13,20.62 91.61,18.11 81.68,18.11 78.71,21.08 65.53,21.08 58.42,28.19 53.34,28.19 52.7,28.83 52.7,33.66 51.94,34.42 51.56,34.42 51.31,34.67 51.31,35.69 v1(52.2,36.58)
  BOTTOM w0.147: v1(103.8,16.42) R549.2 R553.2 ; U91.17 53.49,36.03 52.95,36.58 v1(52.2,36.58)
TEST_LED2: length 280.2
  TOP w0.147: v1(101.96,80.68) 101.57,80.29 99.56,80.29 99.54,80.3 U23.A7
  L03_SIG1 w0.091: v1(156.21,43.96) 149.61,50.56 149.61,59.74 147.68,61.67 147.68,86.48 150.5,89.3 150.5,100.48 154.62,104.61 154.62,119.64 153.36,120.89 147.36,120.89 147.01,121.25 147.01,126.32 J1.7
  L08_SIG2 w0.091: v1(101.96,80.68) 108.23,86.94 108.23,89.94 110.94,92.66 112.08,92.66 116.79,97.37 116.79,116.39 122.45,122.05 140.26,122.05 142.15,123.93 144.62,123.93 J1.7 ; v1(156.21,43.96) 156.21,40.78 155.19,39.77 155.19,18.81 152.65,16.27 152.65,11.44 152.15,10.94 147.83,10.94 146.2,12.56 117.27,12.56 113.56,16.27 106.81,16.27 105.13,14.59 95.73,14.59 95.38,14.25 v1(93.95,14.25)
  BOTTOM w0.147: R552.2 R554.2 v1(93.95,14.25)
TEST_PORZN: length 66.2
  TOP w0.147: v1(130.36,22.45) Q9.1
  L08_SIG2 w0.091: v1(130.36,22.45) 129.52,21.6 124.16,21.6 122.72,20.16 117.13,20.16 113.53,16.56 106.7,16.56 104.94,14.81 93.79,14.81 92.67,13.69 79.28,13.69 74.11,18.85 73.23,18.85 v1(72.62,18.23)
  BOTTOM w0.147: R543.1 v1(72.62,18.23) R521.1
TEST_POWERDOWN: length 140.5
  L08_SIG2 w0.091: v1(73.76,18.23) 78.56,13.43 93.43,13.43 93.73,13.73 96.65,13.73 96.9,13.48 104.39,13.48 106.93,16.02 113.41,16.02 117.12,12.31 141.63,12.31 144.27,9.67 163.79,9.67 171.42,17.3 171.42,42.04 170.45,43.01 v1(170.45,49.18)
  BOTTOM w0.147: v1(73.76,18.23) R542.1 ; R412.1 v1(170.45,49.18)
TEST_WARMRESETN: length 63.1
  TOP w0.147: Q10.1 v1(126.17,22.42)
  L08_SIG2 w0.091: v1(126.17,22.42) 125.68,21.93 124.16,21.93 124.06,21.82 124.06,21.81 122.63,20.39 117.04,20.39 113.44,16.78 106.61,16.78 105.58,15.76 94.46,15.76 92.61,13.91 79.37,13.91 74.2,19.07 72.31,19.07 v1(71.47,18.23)
  BOTTOM w0.147: R522.1 v1(71.47,18.23) R544.1
TM4C129_TCK: length 3.9
  TOP w0.147: U59.100 157.95,31.33 TP37.1
TM4C129_TDI: length 4.1
  TOP w0.147: U59.98 158.75,32.2 TP36.1
TM4C129_TDO: length 2.8
  TOP w0.147: TP38.1 159.68,31.23 159.15,30.7 U59.97
TM4C129_TMS: length 3.5
  TOP w0.147: TP35.1 158.35,32.33 U59.99
TMP1_ADD0: length 3.2
  TOP w0.147: R68.2 R72.2 U18.5
TMP1_ADD1: length 3.1
  TOP w0.147: U18.3 R93.2 R98.2
TMP2_ADD0: length 3.1
  TOP w0.147: R132.1 R133.2 U29.5
TMP2_ADD1: length 3.1
  TOP w0.147: R124.2 R125.2 121.41,68.82 121.48,68.75 U29.3
USB0_AB_DM: length 8.5
  TOP w0.107: J24.2 4.87,53.58 5.14,53.85 5.68,53.85 v1(5.91,53.62)
  BOTTOM w0.107: FL22.4 6.95,56.93 6.68,56.66 6.27,56.66 5.95,56.34 5.95,55.55 5.06,54.66 5.06,54.12 5.36,53.82 5.71,53.82 v1(5.91,53.62) 6.18,53.9 6.66,53.9 U38.1
USB0_AB_DP: length 8.5
  TOP w0.107: J24.3 4.87,54.23 5.03,54.07 5.94,54.07 6.04,54.17 6.04,54.38 5.98,54.44 v1(5.91,54.44)
  BOTTOM w0.107: U38.2 6.63,54.12 6.23,54.12 v1(5.91,54.44) 5.91,54.16 5.79,54.04 5.45,54.04 5.28,54.21 5.28,54.57 6.17,55.46 6.17,56.25 6.36,56.44 6.64,56.44 6.95,56.13 FL22.3
USB0_AB_ID: length 111
  TOP w0.147: U23.U16 v1(85.86,72.7) ; v1(6.73,55.18) 5.94,55.18 5.64,54.88 J24.4
  L03_SIG1 w0.203: J23.5 3.73,48.66 6.15,48.66 6.73,49.24 v1(6.73,55.18)
  L08_SIG2 w0.091: v1(58.57,56.31) 58.84,56.57 59.11,56.57 63.16,60.62 63.16,61.66 63.3,61.8 63.3,62.54 63.86,63.11 63.86,67.47 65.55,69.16 69.65,69.16 70.05,68.76 75.16,68.76 75.34,68.58 76.09,68.58 77.22,67.45 79.52,67.45 81.53,69.46 81.53,69.78 82.3,70.55 82.3,70.94 82.29,70.95 82.29,71.26 82.3,71.27 82.3,71.29 82.77,71.77 83.44,71.77 83.97,72.3 85.24,72.3 85.64,72.7 v1(85.86,72.7)
  BOTTOM w0.147: U38.3 6.77,55.14 v1(6.73,55.18) 7.19,55.18 7.44,55.44 8.18,55.44 10.62,53 34.68,53 36.8,50.88 52.83,50.88 57.75,55.8 58.06,55.8 v1(58.57,56.31)
USB0_DM: length 94.6
  TOP w0.14: U23.AA20 v1(82.66,69.5)
  L08_SIG2 w0.094: v1(82.66,69.5) 82.38,69.78 82.16,69.78 82.04,69.66 82.04,68.01 80.76,66.72 76.29,66.72 74.9,68.12 69.71,68.12 69.31,68.52 65.82,68.52 64.5,67.2 64.5,62.09 63.8,61.39 63.8,60.15 60.65,57 60.65,55.41 59.98,54.73 58.8,54.73 v1(58.59,54.53)
  BOTTOM w0.107: v1(58.59,54.53) 58.8,54.74 59.37,54.74 59.83,55.19 59.83,56.26 58.44,57.66 52.68,57.66 52.34,58 41.39,58 37.59,54.21 14.54,54.21 12.11,56.64 10.31,56.64 10.01,56.93 FL22.1
USB0_DP: length 94.5
  TOP w0.14: U23.AA19 v1(82.66,70.3)
  L08_SIG2 w0.094: v1(58.59,55.35) 58.45,55.21 58.45,55.07 58.55,54.98 59.88,54.98 60.41,55.51 60.41,57.1 63.55,60.25 63.55,61.49 64.26,62.19 64.26,67.3 65.71,68.76 69.41,68.76 69.81,68.36 75,68.36 76.39,66.97 80.66,66.97 81.8,68.11 81.8,69.76 82.06,70.03 82.38,70.03 v1(82.66,70.3)
  BOTTOM w0.107: FL22.2 10.01,56.13 10.31,56.42 12.02,56.42 14.45,53.99 37.68,53.99 41.48,57.78 52.25,57.78 52.59,57.44 58.35,57.44 59.61,56.17 59.61,55.29 59.28,54.96 58.7,54.96 58.59,55.06 v1(58.59,55.35)
USB0_DRVBUS: length 123.5
  TOP w0.147: R151.1 30.3,55.64 30.18,55.77 U36.4 27.83,55.77 27.1,55.04 27.1,49.23 30.76,45.57 33.99,45.57 34.57,46.15 36.45,46.15 36.96,45.64 39.09,45.64 39.67,46.23 43.13,46.23 43.66,46.76 44.42,46.76 46.1,45.09 50.92,45.09 51.35,45.52 53.87,45.52 55.37,47.02 57,47.02 57.71,47.73 60.6,47.73 61.42,46.91 61.42,40.44 60.99,40.01 60.99,36.04 62.94,34.09 77.98,34.09 91.32,47.43 92.33,47.43 93.34,48.43 v1(93.34,49.17) ; U23.E19 v1(96.26,70.3)
  BOTTOM w0.147: v1(96.26,70.3) 96.26,68.3 96.75,67.81 96.75,66.58 96.6,66.43 96.6,63.42 97.44,62.58 97.44,53.27 v1(93.34,49.17)
USB0_RCALIB: length 16.5
  TOP w0.147: U23.U17 v1(85.86,71.9)
  L03_SIG1 w0.091: v1(75.23,73.13) 74.76,72.65 74.76,72.1 74.88,71.98 74.88,71.41 75.43,70.87 81.68,70.87 81.82,70.72 84.42,70.72 84.64,70.95 84.64,71.26 84.9,71.52 85.32,71.52 85.7,71.9 v1(85.86,71.9)
  BOTTOM w0.147: v1(75.23,73.13) 75.23,73.24 TP67.1 74.13,72.75 R605.1
USB0_VBUS: length 11.4
  TOP w0.381: 5.33,52.82 5.23,52.93 J24.1
  BOTTOM w0.254: U38.6 7.37,53.33 6.77,52.72 v1(5.92,52.72) ; R428.1 2.94,42.83 3.23,43.12 5.61,43.12 5.94,43.45 5.94,45.79 J23.1
USB1_SHIELD: length 4.2
  TOP w0.508: J24.9 v1(2.73,54.23)
  L03_SIG1 w0.508: J24.8 2.5,50.14 2.59,50.23 ; J24.10 2.79,58.32 2.79,58.31
  vias: v1(3.3,49.9) v1(4.19,50.79) v1(4.47,58.99)
VCOMH: length 3
  BOTTOM w0.254: J36.2 5.75,16.31 6.3,15.76 C473.1
VDDS_MMC0/ADC0_VREFP: length 2.5
  TOP w0.254: U23.J15 v1(93.06,73.5)
  BOTTOM w0.254: 100.33,67.28 R699.1 ; 100.33,67.28 100.33,66.65 v1(100.46,66.52) ; 100.33,67.28 R698.2 ; C541.1 92.84,73.5 v1(93.06,73.5)
VIO_CAN: length 19.4
  TOP w0.381: U4.5 C8.1 v1(26.03,126.68) ; v1(16.13,122.32) 16.13,122.87 FB1.2 16.47,124.5 16.26,124.71 C3.1 15.54,125.64 15.4,125.78 U3.5
  BOTTOM w0.147: v1(16.13,122.32) 17.78,123.97 19.05,123.97 21.77,126.68 v1(26.03,126.68)
VMAIN: length 49.7
  TOP w0.254: C65.2 149.08,92.23 149.3,92.45 U17.1
  TOP w0.381: C123.1 v1(152.82,60.66) ; R80.2 172.97,95.77
  L03_SIG1 w0.254: v1(139.57,73.28) 139.19,72.9 136.4,72.9 134.75,74.55 v1(120.02,74.55)
  L08_SIG2 w0.254: v1(139.57,73.28) 143.93,73.28 154.12,63.09 v1(154.12,62.2)
  BOTTOM w0.254: U97.2 58.05,24.01 58.04,24.02 ; R604.1 119.51,75.06 v1(120.02,74.55) ; R408.2 v1(172.34,52.08) ; v1(58.04,26.68) 58.17,26.56 58.8,26.56 59.05,26.3 R500.1
  vias: v1(57.02,26.68) v1(57.53,27.32) v1(57.53,26.18) v1(154.57,62.84) v1(159.41,82.7) v1(159.41,81.69) v1(159.41,80.67) v1(159.41,79.66) v1(160.43,82.7) v1(160.43,81.69) v1(160.43,80.67) v1(160.43,79.66) v1(161.44,82.7) v1(161.44,81.69) v1(161.44,80.67) v1(161.44,79.66) v1(162.53,90.85) v1(162.53,89.91) v1(162.53,88.69) v1(162.59,82.7) v1(162.59,81.69) v1(162.59,80.67) v1(162.59,79.66) v1(163.6,82.7) v1(163.6,81.69) v1(163.6,80.67) v1(163.6,79.66) v1(163.75,90.85) v1(163.75,89.91) v1(163.75,88.69) v1(167.51,91.1) v1(167.51,89.88) v1(167.51,88.66) v1(168.73,91.1) v1(168.73,89.88) v1(168.73,88.66) v1(169.95,91.1) v1(169.95,89.88) v1(169.95,88.66) v1(171.17,91.1) v1(171.17,89.88) v1(171.17,88.66)
VMAIN_EN: length 13.1
  TOP w0.254: R577.1 164.47,55.59 165.35,54.7 165.35,52.85 166.12,52.08 SW1.2
  BOTTOM w0.254: C406.1 R408.1 ; R408.1 170.45,51.44 170.95,50.94 171.2,50.94 171.43,50.71 R412.2 ; R408.1 SW1.2
VPHY_3V3_FT4232: length 3.9
  BOTTOM w0.254: U87.4 133.33,40.44 C425.2
  BOTTOM w0.381: FB24.1 131.63,40.93 C425.2
VPLL_3V3_FT4232: length 6.8
  BOTTOM w0.254: FB23.1 132.21,42.94 132.32,42.83 C422.2 133.49,42.83 133.59,42.94 U87.9
  BOTTOM w0.381: R417.2 130.41,44.74 131.4,43.75 FB23.1
VPP_1V8: length 93.2
  TOP w0.147: U23.G15 v1(94.66,73.5)
  L05_PWR1 w0.114: 98.23,73.1 98.42,72.91 98.42,72.9 98.42,72.02 98.15,72.3 95.1,72.3 95.1,72.3 94.49,72.3 94.26,72.54 94.26,73.1 v1(94.66,73.5) 95.06,73.1 98.23,73.1
  L05_PWR1 w0.381: 98.42,72.02 98.93,71.52 98.93,70.66 99.11,70.48 99.42,70.17 100.06,70.17 100.72,69.51 104.42,69.51 105.28,70.37 110.24,70.37 110.62,70.75 110.62,74.18 109.73,75.07 109.73,77.1 109.09,77.74 109.09,80.79 109.6,81.29 110.24,81.29 111,82.06 111,83.49 110.13,84.35 110.13,86.14 111.51,87.52 119.25,87.52 123.06,83.71 126.36,83.71 127.64,84.98 127.64,93.49 129.95,95.8 136,95.8 139.55,99.35 139.55,101 140.46,101.92 TP52.1
  BOTTOM w0.254: 141.82,105.04 142.17,104.7 U72.1 141.9,102.92 141.55,102.92 141.44,102.81 141.04,102.81
VPP_DDR_2V5: length 21
  BOTTOM w0.508: TP47.1 88.52,120.79 82.55,120.79 81.28,119.52 81.28,110.63
VPP_LDO_EN: length 197.8
  TOP w0.147: v1(132.08,23.13) 132.08,27.19 130.94,28.34 130.94,31.89 132.5,33.45 146.47,33.45 149.22,36.21 149.22,37.35 150.37,38.5 151.51,38.5 153.67,40.65 153.67,42.94 152.15,44.46 v1(150.75,44.46)
  L03_SIG1 w0.091: v1(150.75,44.46) 146.81,48.4 146.81,54.24 142.88,58.18 142.88,92.42 144.34,93.89 144.34,99.15 v1(145.03,99.84)
  L08_SIG2 w0.091: v1(51.82,34.94) 52.7,34.94 60.74,26.91 60.74,26.85 64.3,23.29 77.25,23.29 81.92,18.62 91.34,18.62 93.77,21.06 99.41,21.06 102.19,18.28 111.36,18.28 115.19,22.11 122.05,22.11 123.49,23.56 131.65,23.56 v1(132.08,23.13)
  BOTTOM w0.147: R582.2 R263.2 145.54,101.11 TP53.1 145.16,99.96 v1(145.03,99.84) ; v1(51.82,34.94) 51.84,34.91 U91.16
VREF: length 9.6
  TOP w0.203: 143.66,24.54 143.86,24.73 U59.9
  TOP w0.381: 143.66,24.54 C180.1 v1(142.39,24)
  BOTTOM w0.254: U95.3 144.11,23.67 143.78,24 C180.1 ; v1(142.39,24) 141.48,24 R505.2
  BOTTOM w0.381: v1(142.39,24) C180.1
VSENSE: length 12.9
  TOP w0.254: U17.6 146.07,95.38 145.59,95.86 v1(145.59,95.88)
  BOTTOM w0.381: R294.1 R279.2 C272.2 150.98,95.41 150.12,96.28 145.99,96.28 v1(145.59,95.88)
XDS110_DIR: length 3.8
  BOTTOM w0.147: U98.3 125.82,58.63 125.31,59.14 R507.2 124.64,58.19 124.9,57.92 U98.2
XDS110_EMU0: length 24.5
  TOP w0.147: U59.42 150.35,12.85 149.56,12.06 R202.2 148.95,12.06 v1(148.59,11.7) ; U55.8 v1(137.03,26.81)
  L08_SIG2 w0.091: v1(148.59,11.7) 147.99,11.7 146.94,12.75 146.94,17.51 141.53,22.92 140.92,22.92 v1(137.03,26.81)
XDS110_EMU1: length 24.1
  TOP w0.147: U59.43 150.75,12.56 150.79,12.52 R203.2 v1(151.49,12.06) ; U55.1 v1(137.03,23.51)
  L08_SIG2 w0.091: v1(151.49,12.06) 150.69,11.26 148.01,11.26 146.69,12.59 146.69,14.38 137.56,23.51 v1(137.03,23.51)
XDS110_TCK: length 83.2
  TOP w0.147: v1(147.7,16.27) 147.7,15.82 147.52,15.63 147.52,15.09 147.55,15.05 U59.35
  BOTTOM w0.147: U98.12 126.82,53.49 125.64,52.31 125.64,50.89 123.98,49.23 123.98,48.08 122.78,46.89 122.78,34.08 119.28,30.57 119.28,26.76 113.1,20.58 113.1,15.78 115.17,13.71 144.24,13.71 146.8,16.27 v1(147.7,16.27)
XDS110_TDI: length 82.7
  TOP w0.147: U59.38 v1(148.75,12.87)
  BOTTOM w0.147: U98.13 126.32,53.41 125.35,52.43 125.35,51.01 123.6,49.26 123.6,48.18 122.49,47.08 122.49,34.2 118.99,30.7 118.99,26.89 112.81,20.71 112.81,15.66 115.05,13.42 148.21,13.42 v1(148.75,12.87)
XDS110_TDO: length 62.6
  TOP w0.147: U56.7 120.3,53.66 v1(120.26,53.7) ; v1(147.96,12.33) 148.27,12.65 148.27,13.04 148.35,13.11 U59.37
  L03_SIG1 w0.091: v1(147.96,12.33) 146.53,13.76 146.53,16.26 142.44,20.35 131.37,20.35 125.07,26.64 125.07,49.23 121.67,52.63 120.93,52.63 120.26,53.3 v1(120.26,53.7)
XDS110_TMS: length 84.1
  TOP w0.147: v1(148,15.38) 147.95,15.33 U59.36
  BOTTOM w0.147: U98.11 127.32,51.31 125.43,49.42 125.26,49.25 125.26,48.81 123.15,46.7 123.15,33.93 119.58,30.36 119.58,26.64 113.4,20.46 113.4,15.91 115.3,14.01 143.99,14.01 146.78,16.8 148.2,16.8 148.36,16.64 148.36,15.74 v1(148,15.38)
XDS110_TRST#: length 87.2
  TOP w0.147: U59.40 v1(149.55,12.84)
  BOTTOM w0.147: v1(149.55,12.84) 149.89,13.18 149.89,15.82 148.62,17.09 146.66,17.09 143.87,14.3 115.42,14.3 113.69,16.03 113.69,20.34 119.87,26.52 119.87,30.23 123.44,33.81 123.44,46.58 125.55,48.69 125.55,49.12 127.82,51.39 U98.10
XDS_RSTN: length 3.3
  TOP w0.147: U59.70 161.51,17.53 161.78,17.79 R199.1 R198.1
XDS_USB_DM: length 24.7
  TOP w0.107: U58.5 170.88,23.38 171.02,23.24 171.22,23.24 171.32,23.35 171.32,23.76 171.58,24.02 171.89,24.02 v1(172.25,24.37) 172.55,24.07 172.84,24.07 173.05,24.29 J28.2 ; U59.93 159.66,26.73 159.59,26.8 158.48,26.8 158.37,26.69 v1(158.37,26.52)
  BOTTOM w0.107: v1(158.37,26.52) 158.47,26.52 158.58,26.63 158.58,26.8 158.48,26.9 157.88,26.9 157.57,26.59 157.57,25.63 158.49,24.71 166.75,24.71 167.39,24.07 171.95,24.07 v1(172.25,24.37)
